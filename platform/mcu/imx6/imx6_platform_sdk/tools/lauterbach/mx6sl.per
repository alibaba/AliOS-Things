group.long 0x264++0x3
    line.long 0x00 "GPU_PUPSCR,Power Up Sequence Control Register"
        hexmask.long.byte 0x00 0.--6. 1. " SW ,After a power-up request (pup_req assertion), the PGC waits a number of clocks equal to the value of SW before asserting switch_b."
        textline "          "
        hexmask.long.byte 0x00 8.--14. 1. " SW2ISO ,After asserting switch_b, the PGC waits a number of clocks equal to the value of SW2ISO before negating isolation."
width 11.
group.long 0x268++0x3
    line.long 0x00 "GPU_PDNSCR,Pull Down Sequence Control Register"
        hexmask.long.byte 0x00 0.--6. 1. " ISO ,After a power-down request (pdn_req assertion), the PGC waits a number of clocks equal to the value of ISO before asserting isolation."
        textline "          "
        hexmask.long.byte 0x00 8.--14. 1. " ISO2SW ,After asserting isolation, the PGC waits a number of clocks equal to the value of ISO2SW before negating switch_b."
width 7.
group.long 0x26c++0x3
    line.long 0x00 "GPU_SR,Power Gating Controller Status Register"
        bitfld.long 0x00 0. " PSR ,Power status." "0,1"
width 9.
group.long 0x2a0++0x3
    line.long 0x00 "CPU_CTRL,PGC Control Register"
        bitfld.long 0x00 0. " PCR ,Power Control PCR must not change from power-down request (pdn_req) assertion until the target subsystem is completely powered up." "0,1"
width 11.
group.long 0x2a4++0x3
    line.long 0x00 "CPU_PUPSCR,Power Up Sequence Control Register"
        hexmask.long.byte 0x00 0.--6. 1. " SW ,After a power-up request (pup_req assertion), the PGC waits a number of clocks equal to the value of SW before asserting switch_b."
        textline "          "
        hexmask.long.byte 0x00 8.--14. 1. " SW2ISO ,After asserting switch_b, the PGC waits a number of clocks equal to the value of SW2ISO before negating isolation."
width 11.
group.long 0x2a8++0x3
    line.long 0x00 "CPU_PDNSCR,Pull Down Sequence Control Register"
        hexmask.long.byte 0x00 0.--6. 1. " ISO ,After a power-down request (pdn_req assertion), the PGC waits a number of clocks equal to the value of ISO before asserting isolation."
        textline "          "
        hexmask.long.byte 0x00 8.--14. 1. " ISO2SW ,After asserting isolation, the PGC waits a number of clocks equal to the value of ISO2SW before negating switch_b."
width 7.
group.long 0x2ac++0x3
    line.long 0x00 "CPU_SR,Power Gating Controller Status Register"
        bitfld.long 0x00 0. " PSR ,Power status." "0,1"


tree.end



;--------------------------------------------------------------------------------
; PMU
;--------------------------------------------------------------------------------
tree "PMU"
    base ad:0x020c8000

width 8.
group.long 0x110++0x3
    line.long 0x00 "REG_1P1,Regulator 1P1 Register"
        bitfld.long 0x00 0. " ENABLE_LINREG ,Control bit to enable the regulator output." "0,1"
        textline "       "
        bitfld.long 0x00 1. " ENABLE_BO ,Control bit to enable the brown-out circuitry in the regulator." "0,1"
        textline "       "
        bitfld.long 0x00 2. " ENABLE_ILIMIT ,Control bit to enable the current-limit circuitry in the regulator." "0,1"
        textline "       "
        bitfld.long 0x00 3. " ENABLE_PULLDOWN ,Control bit to enable the pull-down circuitry in the regulator" "0,1"
        textline "       "
        hexmask.long.byte 0x00 4.--7. 1. " BO_OFFSET ,Control bits to adjust the regulator brown-out offset voltage in 25mV steps."
        textline "       "
        hexmask.long.byte 0x00 8.--13. 1. " OUTPUT_TRG ,Control bits to adjust the regulator output voltage."
        textline "       "
        bitfld.long 0x00 16. " BO_VDD1P1 ,Status bit that signals when a brown-out is detected on the regulator output." "0,1"
        textline "       "
        bitfld.long 0x00 17. " OK_VDD1P1 ,Status bit that signals when the regulator output is ok." "0,1"
width 8.
group.long 0x120++0x3
    line.long 0x00 "REG_3P0,Regulator 3P0 Register"
        bitfld.long 0x00 0. " ENABLE_LINREG ,Control bit to enable the regulator output to be set by the programmed target voltage setting and internal bandgap reference." "0,1"
        textline "       "
        bitfld.long 0x00 1. " ENABLE_BO ,Control bit to enable the brown-out circuitry in the regulator." "0,1"
        textline "       "
        bitfld.long 0x00 2. " ENABLE_ILIMIT ,Control bit to enable the current-limit circuitry in the regulator." "0,1"
        textline "       "
        hexmask.long.byte 0x00 4.--7. 1. " BO_OFFSET ,Control bits to adjust the regulator brown-out offset voltage in 25mV steps."
        textline "       "
        bitfld.long 0x00 7. " VBUS_SEL ,Select input voltage source for LDO_3P0 from either USB_OTG1_VBUS or USB_OTG2_VBUS." "0,1"
        textline "       "
        hexmask.long.byte 0x00 8.--13. 1. " OUTPUT_TRG ,Control bits to adjust the regulator output voltage."
        textline "       "
        bitfld.long 0x00 16. " BO_VDD3P0 ,Status bit that signals when a brown-out is detected on the regulator output." "0,1"
        textline "       "
        bitfld.long 0x00 17. " OK_VDD3P0 ,Status bit that signals when the regulator output is ok." "0,1"
width 8.
group.long 0x130++0x3
    line.long 0x00 "REG_2P5,Regulator 2P5 Register"
        bitfld.long 0x00 0. " ENABLE_LINREG ,Control bit to enable the regulator output." "0,1"
        textline "       "
        bitfld.long 0x00 1. " ENABLE_BO ,Control bit to enable the brown-out circuitry in the regulator." "0,1"
        textline "       "
        bitfld.long 0x00 2. " ENABLE_ILIMIT ,Control bit to enable the current-limit circuitry in the regulator." "0,1"
        textline "       "
        bitfld.long 0x00 3. " ENABLE_PULLDOWN ,Control bit to enable the pull-down circuitry in the regulator" "0,1"
        textline "       "
        hexmask.long.byte 0x00 4.--7. 1. " BO_OFFSET ,Control bits to adjust the regulator brown-out offset voltage in 25mV steps."
        textline "       "
        hexmask.long.byte 0x00 8.--13. 1. " OUTPUT_TRG ,Control bits to adjust the regulator output voltage."
        textline "       "
        bitfld.long 0x00 16. " BO_VDD2P5 ,Status bit that signals when a brown-out is detected on the regulator output." "0,1"
        textline "       "
        bitfld.long 0x00 17. " OK_VDD2P5 ,Status bit that signals when the regulator output is ok." "0,1"
        textline "       "
        bitfld.long 0x00 18. " ENABLE_WEAK_LINREG ,Enables the weak 2p5 regulator." "0,1"
width 9.
group.long 0x140++0x3
    line.long 0x00 "REG_CORE,Digital Regulator Core Register"
        hexmask.long.byte 0x00 0.--5. 1. " REG0_TARG ,This bitfield defines the target voltage for the arm core power domain."
        textline "        "
        hexmask.long.byte 0x00 5.--9. 1. " REG0_ADJ ,This bitfield defines the adjustment bits to calibrate the target value of REG1 (ARM_CORE)."
        textline "        "
        hexmask.long.byte 0x00 9.--14. 1. " REG1_TARG ,This bitfield defines the target voltage for the VPU/GPU power domain."
        textline "        "
        hexmask.long.byte 0x00 14.--18. 1. " REG1_ADJ ,This bitfield defines the adjustment bits to calibrate the target value of REG1 (REG_PU)."
        textline "        "
        hexmask.long.byte 0x00 18.--23. 1. " REG2_TARG ,This bitfield defines the target voltage for the SOC power domain."
        textline "        "
        hexmask.long.byte 0x00 23.--27. 1. " REG2_ADJ ,This bitfield defines the adjustment bits to calibrate the target value of REG2 (REG_SOC)."
        textline "        "
        bitfld.long 0x00 29. " FET_ODRIVE ,If set, increases the gate drive on power gating fets to reduce leakage in the off state." "0,1"
width 6.
group.long 0x150++0x3
    line.long 0x00 "MISC0,Miscellaneous Register 0"
        bitfld.long 0x00 0. " REFTOP_PWD ,Control bit to power-down the analog bandgap reference circuitry." "0,1"
        textline "     "
        bitfld.long 0x00 3. " REFTOP_SELFBIASOFF ,Control bit to disable the self-bias circuit in the analog bandgap." "0,1"
        textline "     "
        hexmask.long.byte 0x00 4.--7. 1. " REFTOP_VBGADJ ,"
        textline "     "
        bitfld.long 0x00 7. " REFTOP_VBGUP ,Status bit which signals that the analog bandgap voltage is up and stable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 11.--13. 1. " STOP_MODE_CONFIG ,Configure the analog behavior in stop mode."
        textline "     "
        bitfld.long 0x00 13. " DISCON_HIGH_SNVS ,This bit forces the short between VDDHIGH_IN and VSNVS_IN to open when asserted." "0,1"
        textline "     "
        hexmask.long.byte 0x00 14.--16. 1. " OSC_I ,This bit field determines the bias current in the 24MHz oscillator."
        textline "     "
        bitfld.long 0x00 16. " OSC_XTALOK ,Status bit which signals that the output of the 24MHz crystal oscillator is stable." "0,1"
        textline "     "
        bitfld.long 0x00 17. " OSC_XTALOK_EN ,This bit enables the detector which signals when the 24MHz crystal oscillator is stable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 18.--20. 1. " WBCP_VPW_THRESH ,This signal alters the voltage that the pwell is charged pumped to."
        textline "     "
        bitfld.long 0x00 25. " CLKGATE_CTRL ,This bit allows disabling the clock gate (always un-gated) for the xtal 24MHz clock that clocks the digital logic in the analog block." "0,1"
        textline "     "
        hexmask.long.byte 0x00 26.--29. 1. " CLKGATE_DELAY ,This field specifies the delay between powering up the XTAL 24MHz clock and release the clock to the digital logic inside the analog block."
width 6.
group.long 0x160++0x3
    line.long 0x00 "MISC1,Miscellaneous Register 1"
        hexmask.long.byte 0x00 0.--5. 1. " LVDS1_CLK_SEL ,This field selects the clk to be routed to anaclk2/2b."
        textline "     "
        bitfld.long 0x00 10. " LVDSCLK1_OBEN ,This enables the lvds output buffer for anaclk1/1b." "0,1"
        textline "     "
        bitfld.long 0x00 12. " LVDSCLK1_IBEN ,This enables the lvds input buffer for anaclk1/1b." "0,1"
        textline "     "
        bitfld.long 0x00 29. " IRQ_TEMPSENSE ,This status bit is set to one when when the temperature sensor interrupt asserts." "0,1"
        textline "     "
        bitfld.long 0x00 30. " IRQ_ANA_BO ,This status bit is set to one when when any of the analog regulator brownout interrupts assert." "0,1"
        textline "     "
        bitfld.long 0x00 31. " IRQ_DIG_BO ,This status bit is set to one when when any of the digital regulator brownout interrupts assert." "0,1"
width 6.
group.long 0x170++0x3
    line.long 0x00 "MISC2,Miscellaneous Register 2"
        hexmask.long.byte 0x00 0.--3. 1. " REG0_BO_OFFSET ,This bit field defines the brown out voltage offset for the CORE power domain."
        textline "     "
        bitfld.long 0x00 3. " REG0_BO_STATUS ,Reg0 brownout status bit." "0,1"
        textline "     "
        bitfld.long 0x00 5. " REG0_ENABLE_BO ,Enables the brownout detection." "0,1"
        textline "     "
        bitfld.long 0x00 7. " PLL3_DISABLE ,Default value of ""0""." "0,1"
        textline "     "
        hexmask.long.byte 0x00 8.--11. 1. " REG1_BO_OFFSET ,This bit field defines the brown out voltage offset for the xPU power domain."
        textline "     "
        bitfld.long 0x00 11. " REG1_BO_STATUS ,Reg1 brownout status bit." "0,1"
        textline "     "
        bitfld.long 0x00 13. " REG1_ENABLE_BO ,Enables the brownout detection." "0,1"
        textline "     "
        bitfld.long 0x00 15. " AUDIO_DIV_LSB ,LSB of Audio Pll post divider two bit control: 0x0=div-by-1(default), 0x1=div-by-2, 0x2-div-by-1, 0x3=div-by-4." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--19. 1. " REG2_BO_OFFSET ,This bit field defines the brown out voltage offset for the xPU power domain."
        textline "     "
        bitfld.long 0x00 19. " REG2_BO_STATUS ,Reg2 brownout status bit." "0,1"
        textline "     "
        bitfld.long 0x00 21. " REG2_ENABLE_BO ,Enables the brownout detection." "0,1"
        textline "     "
        bitfld.long 0x00 22. " REG2_OK ,Signals that the voltage is above the brownout level for the SOC supply." "0,1"
        textline "     "
        bitfld.long 0x00 23. " AUDIO_DIV_MSB ,MSB of 2 bit post-divider field for the Audio PLL: 0x0=div-by-1(default), 0x1=div-by-2, 0x2=div-by-1, 0x3=div-by-4." "0,1"
        textline "     "
        hexmask.long.byte 0x00 24.--26. 1. " REG0_STEP_TIME ,Number of clock periods (24MHz clock)."
        textline "     "
        hexmask.long.byte 0x00 26.--28. 1. " REG1_STEP_TIME ,Number of clock periods (24MHz clock)."
        textline "     "
        hexmask.long.byte 0x00 28.--30. 1. " REG2_STEP_TIME ,Number of clock periods (24MHz clock)."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " VIDEO_DIV ,Post-divider for video PLL."
width 12.
group.long 0x260++0x3
    line.long 0x00 "LOWPWR_CTRL,Low Power Control Register"
        bitfld.long 0x00 0. " RC_OSC_EN ,RC Osc." "0,1"
        textline "           "
        hexmask.long.byte 0x00 1.--4. 1. " RC_OSC_PROG ,RC osc."
        textline "           "
        bitfld.long 0x00 4. " OSC_SEL ,Select the source for the 24MHz clock." "0,1"
        textline "           "
        bitfld.long 0x00 5. " LPBG_SEL ,Bandgap select." "0,1"
        textline "           "
        bitfld.long 0x00 6. " LPBG_TEST ,Low power bandgap test bit." "0,1"
        textline "           "
        bitfld.long 0x00 7. " REFTOP_IBIAS_OFF ,Low power reftop ibias disable." "0,1"
        textline "           "
        bitfld.long 0x00 8. " L1_PWRGATE ,L1 power gate control." "0,1"
        textline "           "
        bitfld.long 0x00 9. " L2_PWRGATE ,L2 power gate control." "0,1"
        textline "           "
        bitfld.long 0x00 10. " CPU_PWRGATE ,CPU power gate control." "0,1"
        textline "           "
        bitfld.long 0x00 11. " DISPLAY_PWRGATE ,Display logic power gate control." "0,1"
        textline "           "
        bitfld.long 0x00 12. " RWB_EN ,Reverse well bias enable control." "0,1"
        textline "           "
        bitfld.long 0x00 13. " RCOSC_CG_OVERRIDE ,For debug purposes only." "0,1"
        textline "           "
        hexmask.long.byte 0x00 14.--16. 1. " XTALOSC_PWRUP_DELAY ,Specifies the time delay between when the 24MHz xtal is powered up until it is stable and ready to use."
        textline "           "
        bitfld.long 0x00 16. " XTALOSC_PWRUP_STAT ,Status of the 24MHz xtal oscillator." "0,1"


tree.end



;--------------------------------------------------------------------------------
; PWM
;--------------------------------------------------------------------------------
tree.open "PWM"
    tree "PWM1"
        base ad:0x02080000

width 6.
group.long 0x0++0x3
    line.long 0x00 "PWMCR,PWM Control Register"
        bitfld.long 0x00 0. " EN ,PWM Enable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 1.--3. 1. " REPEAT ,Sample Repeat."
        textline "     "
        bitfld.long 0x00 3. " SWR ,Software Reset." "0,1"
        textline "     "
        hexmask.long.word 0x00 4.--16. 1. " PRESCALER ,Counter Clock Prescaler Value."
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " CLKSRC ,Select Clock Source."
        textline "     "
        hexmask.long.byte 0x00 18.--20. 1. " POUTC ,PWM Output Configuration."
        textline "     "
        bitfld.long 0x00 20. " HCTR ,Half-word Data Swap Control." "0,1"
        textline "     "
        bitfld.long 0x00 21. " BCTR ,Byte Data Swap Control." "0,1"
        textline "     "
        bitfld.long 0x00 22. " DBGEN ,Debug Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 23. " WAITEN ,Wait Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 24. " DOZEN ,Doze Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 25. " STOPEN ,Stop Mode Enable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 26.--28. 1. " FWM ,FIFO Water Mark."
width 6.
group.long 0x4++0x3
    line.long 0x00 "PWMSR,PWM Status Register"
        hexmask.long.byte 0x00 0.--3. 1. " FIFOAV ,FIFO Available."
        textline "     "
        bitfld.long 0x00 3. " FE ,FIFO Empty Status Bit." "0,1"
        textline "     "
        bitfld.long 0x00 4. " ROV ,Roll-over Status." "0,1"
        textline "     "
        bitfld.long 0x00 5. " CMP ,Compare Status." "0,1"
        textline "     "
        bitfld.long 0x00 6. " FWE ,FIFO Write Error Status." "0,1"
width 6.
group.long 0x8++0x3
    line.long 0x00 "PWMIR,PWM Interrupt Register"
        bitfld.long 0x00 0. " FIE ,FIFO Empty Interrupt Enable." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RIE ,Roll-over Interrupt Enable." "0,1"
        textline "     "
        bitfld.long 0x00 2. " CIE ,Compare Interrupt Enable." "0,1"
width 7.
group.long 0xc++0x3
    line.long 0x00 "PWMSAR,PWM Sample Register"
        hexmask.long.word 0x00 0.--16. 1. " SAMPLE ,Sample Value."
width 6.
group.long 0x10++0x3
    line.long 0x00 "PWMPR,PWM Period Register"
        hexmask.long.word 0x00 0.--16. 1. " PERIOD ,Period Value."
width 7.
rgroup.long 0x14++0x3
    line.long 0x00 "PWMCNR,PWM Counter Register"
        hexmask.long.word 0x00 0.--16. 1. " COUNT ,Counter Value."


    tree.end
    tree "PWM2"
        base ad:0x02084000

width 6.
group.long 0x0++0x3
    line.long 0x00 "PWMCR,PWM Control Register"
        bitfld.long 0x00 0. " EN ,PWM Enable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 1.--3. 1. " REPEAT ,Sample Repeat."
        textline "     "
        bitfld.long 0x00 3. " SWR ,Software Reset." "0,1"
        textline "     "
        hexmask.long.word 0x00 4.--16. 1. " PRESCALER ,Counter Clock Prescaler Value."
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " CLKSRC ,Select Clock Source."
        textline "     "
        hexmask.long.byte 0x00 18.--20. 1. " POUTC ,PWM Output Configuration."
        textline "     "
        bitfld.long 0x00 20. " HCTR ,Half-word Data Swap Control." "0,1"
        textline "     "
        bitfld.long 0x00 21. " BCTR ,Byte Data Swap Control." "0,1"
        textline "     "
        bitfld.long 0x00 22. " DBGEN ,Debug Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 23. " WAITEN ,Wait Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 24. " DOZEN ,Doze Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 25. " STOPEN ,Stop Mode Enable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 26.--28. 1. " FWM ,FIFO Water Mark."
width 6.
group.long 0x4++0x3
    line.long 0x00 "PWMSR,PWM Status Register"
        hexmask.long.byte 0x00 0.--3. 1. " FIFOAV ,FIFO Available."
        textline "     "
        bitfld.long 0x00 3. " FE ,FIFO Empty Status Bit." "0,1"
        textline "     "
        bitfld.long 0x00 4. " ROV ,Roll-over Status." "0,1"
        textline "     "
        bitfld.long 0x00 5. " CMP ,Compare Status." "0,1"
        textline "     "
        bitfld.long 0x00 6. " FWE ,FIFO Write Error Status." "0,1"
width 6.
group.long 0x8++0x3
    line.long 0x00 "PWMIR,PWM Interrupt Register"
        bitfld.long 0x00 0. " FIE ,FIFO Empty Interrupt Enable." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RIE ,Roll-over Interrupt Enable." "0,1"
        textline "     "
        bitfld.long 0x00 2. " CIE ,Compare Interrupt Enable." "0,1"
width 7.
group.long 0xc++0x3
    line.long 0x00 "PWMSAR,PWM Sample Register"
        hexmask.long.word 0x00 0.--16. 1. " SAMPLE ,Sample Value."
width 6.
group.long 0x10++0x3
    line.long 0x00 "PWMPR,PWM Period Register"
        hexmask.long.word 0x00 0.--16. 1. " PERIOD ,Period Value."
width 7.
rgroup.long 0x14++0x3
    line.long 0x00 "PWMCNR,PWM Counter Register"
        hexmask.long.word 0x00 0.--16. 1. " COUNT ,Counter Value."


    tree.end
    tree "PWM3"
        base ad:0x02088000

width 6.
group.long 0x0++0x3
    line.long 0x00 "PWMCR,PWM Control Register"
        bitfld.long 0x00 0. " EN ,PWM Enable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 1.--3. 1. " REPEAT ,Sample Repeat."
        textline "     "
        bitfld.long 0x00 3. " SWR ,Software Reset." "0,1"
        textline "     "
        hexmask.long.word 0x00 4.--16. 1. " PRESCALER ,Counter Clock Prescaler Value."
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " CLKSRC ,Select Clock Source."
        textline "     "
        hexmask.long.byte 0x00 18.--20. 1. " POUTC ,PWM Output Configuration."
        textline "     "
        bitfld.long 0x00 20. " HCTR ,Half-word Data Swap Control." "0,1"
        textline "     "
        bitfld.long 0x00 21. " BCTR ,Byte Data Swap Control." "0,1"
        textline "     "
        bitfld.long 0x00 22. " DBGEN ,Debug Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 23. " WAITEN ,Wait Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 24. " DOZEN ,Doze Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 25. " STOPEN ,Stop Mode Enable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 26.--28. 1. " FWM ,FIFO Water Mark."
width 6.
group.long 0x4++0x3
    line.long 0x00 "PWMSR,PWM Status Register"
        hexmask.long.byte 0x00 0.--3. 1. " FIFOAV ,FIFO Available."
        textline "     "
        bitfld.long 0x00 3. " FE ,FIFO Empty Status Bit." "0,1"
        textline "     "
        bitfld.long 0x00 4. " ROV ,Roll-over Status." "0,1"
        textline "     "
        bitfld.long 0x00 5. " CMP ,Compare Status." "0,1"
        textline "     "
        bitfld.long 0x00 6. " FWE ,FIFO Write Error Status." "0,1"
width 6.
group.long 0x8++0x3
    line.long 0x00 "PWMIR,PWM Interrupt Register"
        bitfld.long 0x00 0. " FIE ,FIFO Empty Interrupt Enable." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RIE ,Roll-over Interrupt Enable." "0,1"
        textline "     "
        bitfld.long 0x00 2. " CIE ,Compare Interrupt Enable." "0,1"
width 7.
group.long 0xc++0x3
    line.long 0x00 "PWMSAR,PWM Sample Register"
        hexmask.long.word 0x00 0.--16. 1. " SAMPLE ,Sample Value."
width 6.
group.long 0x10++0x3
    line.long 0x00 "PWMPR,PWM Period Register"
        hexmask.long.word 0x00 0.--16. 1. " PERIOD ,Period Value."
width 7.
rgroup.long 0x14++0x3
    line.long 0x00 "PWMCNR,PWM Counter Register"
        hexmask.long.word 0x00 0.--16. 1. " COUNT ,Counter Value."


    tree.end
    tree "PWM4"
        base ad:0x0208c000

width 6.
group.long 0x0++0x3
    line.long 0x00 "PWMCR,PWM Control Register"
        bitfld.long 0x00 0. " EN ,PWM Enable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 1.--3. 1. " REPEAT ,Sample Repeat."
        textline "     "
        bitfld.long 0x00 3. " SWR ,Software Reset." "0,1"
        textline "     "
        hexmask.long.word 0x00 4.--16. 1. " PRESCALER ,Counter Clock Prescaler Value."
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " CLKSRC ,Select Clock Source."
        textline "     "
        hexmask.long.byte 0x00 18.--20. 1. " POUTC ,PWM Output Configuration."
        textline "     "
        bitfld.long 0x00 20. " HCTR ,Half-word Data Swap Control." "0,1"
        textline "     "
        bitfld.long 0x00 21. " BCTR ,Byte Data Swap Control." "0,1"
        textline "     "
        bitfld.long 0x00 22. " DBGEN ,Debug Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 23. " WAITEN ,Wait Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 24. " DOZEN ,Doze Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 25. " STOPEN ,Stop Mode Enable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 26.--28. 1. " FWM ,FIFO Water Mark."
width 6.
group.long 0x4++0x3
    line.long 0x00 "PWMSR,PWM Status Register"
        hexmask.long.byte 0x00 0.--3. 1. " FIFOAV ,FIFO Available."
        textline "     "
        bitfld.long 0x00 3. " FE ,FIFO Empty Status Bit." "0,1"
        textline "     "
        bitfld.long 0x00 4. " ROV ,Roll-over Status." "0,1"
        textline "     "
        bitfld.long 0x00 5. " CMP ,Compare Status." "0,1"
        textline "     "
        bitfld.long 0x00 6. " FWE ,FIFO Write Error Status." "0,1"
width 6.
group.long 0x8++0x3
    line.long 0x00 "PWMIR,PWM Interrupt Register"
        bitfld.long 0x00 0. " FIE ,FIFO Empty Interrupt Enable." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RIE ,Roll-over Interrupt Enable." "0,1"
        textline "     "
        bitfld.long 0x00 2. " CIE ,Compare Interrupt Enable." "0,1"
width 7.
group.long 0xc++0x3
    line.long 0x00 "PWMSAR,PWM Sample Register"
        hexmask.long.word 0x00 0.--16. 1. " SAMPLE ,Sample Value."
width 6.
group.long 0x10++0x3
    line.long 0x00 "PWMPR,PWM Period Register"
        hexmask.long.word 0x00 0.--16. 1. " PERIOD ,Period Value."
width 7.
rgroup.long 0x14++0x3
    line.long 0x00 "PWMCNR,PWM Counter Register"
        hexmask.long.word 0x00 0.--16. 1. " COUNT ,Counter Value."


    tree.end

tree.end



;--------------------------------------------------------------------------------
; PXP
;--------------------------------------------------------------------------------
tree "PXP"
    base ad:0x020f0000

width 5.
group.long 0x0++0x3
    line.long 0x00 "CTRL,Control Register 0"
        bitfld.long 0x00 0. " ENABLE ,Enables PXP operation with specified parameters." "0,1"
        textline "    "
        bitfld.long 0x00 1. " IRQ_ENABLE ,Interrupt enable." "0,1"
        textline "    "
        bitfld.long 0x00 2. " NEXT_IRQ_ENABLE ,Next command interrupt enable." "0,1"
        textline "    "
        bitfld.long 0x00 3. " LUT_DMA_IRQ_ENABLE ,LUT DMA interrupt enable." "0,1"
        textline "    "
        bitfld.long 0x00 4. " ENABLE_LCD_HANDSHAKE ,Enable handshake with LCD controller." "0,1"
        textline "    "
        hexmask.long.byte 0x00 8.--10. 1. " ROTATE ,Indicates the clockwise rotation to be applied at the output buffer."
        textline "    "
        bitfld.long 0x00 10. " HFLIP ,Indicates that the output buffer should be flipped horizontally (effect applied before rotation)." "0,1"
        textline "    "
        bitfld.long 0x00 11. " VFLIP ,Indicates that the output buffer should be flipped vertically (effect applied before rotation)." "0,1"
        textline "    "
        bitfld.long 0x00 22. " ROT_POS ,This bit controls where rotation will occur in the PXP datapath." "0,1"
        textline "    "
        bitfld.long 0x00 23. " BLOCK_SIZE ,Select the block size to process." "0,1"
        textline "    "
        bitfld.long 0x00 28. " EN_REPEAT ,Enable the PXP to run continuously." "0,1"
        textline "    "
        bitfld.long 0x00 30. " CLKGATE ,This bit must be set to zero for normal operation." "0,1"
        textline "    "
        bitfld.long 0x00 31. " SFTRST ,Set this bit to zero to enable normal PXP operation." "0,1"
width 5.
group.long 0x10++0x3
    line.long 0x00 "STAT,Status Register"
        bitfld.long 0x00 0. " IRQ ,Indicates current PXP interrupt status." "0,1"
        textline "    "
        bitfld.long 0x00 1. " AXI_WRITE_ERROR ,Indicates PXP encountered an AXI write error and processing has been terminated." "0,1"
        textline "    "
        bitfld.long 0x00 2. " AXI_READ_ERROR ,Indicates PXP encountered an AXI read error and processing has been terminated." "0,1"
        textline "    "
        bitfld.long 0x00 3. " NEXT_IRQ ,Indicates that a command issued with the ""Next Command"" functionality has been issued and that a new command may be initiated with a write to the PXP_NEXT register." "0,1"
        textline "    "
        hexmask.long.byte 0x00 4.--8. 1. " AXI_ERROR_ID ,Indicates the AXI ID of the failing bus operation."
        textline "    "
        bitfld.long 0x00 8. " LUT_DMA_LOAD_DONE_IRQ ,Indicates that the LUT DMA transfer has completed." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--24. 1. " BLOCKY ,Indicates the X coordinate of the block currently being rendered."
        textline "    "
        hexmask.long.byte 0x00 24.--32. 1. " BLOCKX ,Indicates the X coordinate of the block currently being rendered."
width 9.
group.long 0x20++0x3
    line.long 0x00 "OUT_CTRL,Output Buffer Control Register"
        hexmask.long.byte 0x00 0.--5. 1. " FORMAT ,Output framebuffer format."
        textline "        "
        hexmask.long.byte 0x00 8.--10. 1. " INTERLACED_OUTPUT ,Determines how the PXP writes it's output data."
        textline "        "
        bitfld.long 0x00 23. " ALPHA_OUTPUT ,Indicates that alpha component in output buffer pixels should be overwritten by PXP_OUT_CTRL[ALPHA]." "0,1"
        textline "        "
        hexmask.long.byte 0x00 24.--32. 1. " ALPHA ,When generating an output buffer with an alpha component, the value in this field will be used when enabled to override the alpha passed through the pixel data pipeline."
width 8.
group.long 0x30++0x3
    line.long 0x00 "OUT_BUF,Output Frame Buffer Pointer"
        hexmask.long.long 0x00 0.--32. 1. " ADDR ,Current address pointer for the output frame buffer."
width 9.
group.long 0x40++0x3
    line.long 0x00 "OUT_BUF2,Output Frame Buffer Pointer #2"
        hexmask.long.long 0x00 0.--32. 1. " ADDR ,Current address pointer for the output frame buffer."
width 10.
group.long 0x50++0x3
    line.long 0x00 "OUT_PITCH,Output Buffer Pitch"
        hexmask.long.word 0x00 0.--16. 1. " PITCH ,Indicates the number of bytes in memory between two vertically adjacent pixels."
width 8.
group.long 0x60++0x3
    line.long 0x00 "OUT_LRC,Output Surface Lower Right Coordinate"
        hexmask.long.word 0x00 0.--14. 1. " Y ,Indicates the number of vertical PIXELS in the output surface (non-rotated)."
        textline "       "
        hexmask.long.word 0x00 16.--30. 1. " X ,Indicates number of horizontal PIXELS in the output surface (non-rotated)."
width 11.
group.long 0x70++0x3
    line.long 0x00 "OUT_PS_ULC,Processed Surface Upper Left Coordinate"
        hexmask.long.word 0x00 0.--14. 1. " Y ,This field indicates the upper left Y-coordinate (in pixels) of the processed surface in the output buffer."
        textline "          "
        hexmask.long.word 0x00 16.--30. 1. " X ,This field indicates the upper left X-coordinate (in pixels) of the processed surface (PS) in the output buffer."
width 11.
group.long 0x80++0x3
    line.long 0x00 "OUT_PS_LRC,Processed Surface Lower Right Coordinate"
        hexmask.long.word 0x00 0.--14. 1. " Y ,This field indicates the lower right Y-coordinate (in pixels) of the processed surface in the output frame buffer."
        textline "          "
        hexmask.long.word 0x00 16.--30. 1. " X ,This field indicates the lower right X-coordinate (in pixels) of the processed surface (PS) in the output frame buffer."
width 11.
group.long 0x90++0x3
    line.long 0x00 "OUT_AS_ULC,Alpha Surface Upper Left Coordinate"
        hexmask.long.word 0x00 0.--14. 1. " Y ,This field indicates the upper left Y-coordinate (in pixels) of the alpha surface in the output frame buffer."
        textline "          "
        hexmask.long.word 0x00 16.--30. 1. " X ,This field indicates the upper left X-coordinate (in pixels) of the alpha surface (AS) in the output frame buffer."
width 11.
group.long 0xa0++0x3
    line.long 0x00 "OUT_AS_LRC,Alpha Surface Lower Right Coordinate"
        hexmask.long.word 0x00 0.--14. 1. " Y ,This field indicates the lower right Y-coordinate (in pixels) of the alpha surface in the output frame buffer."
        textline "          "
        hexmask.long.word 0x00 16.--30. 1. " X ,This field indicates the lower right X-coordinate (in pixels) of the alpha surface (AS) in the output frame buffer."
width 8.
group.long 0xb0++0x3
    line.long 0x00 "PS_CTRL,Processed Surface (PS) Control Register"
        hexmask.long.byte 0x00 0.--5. 1. " FORMAT ,PS buffer format."
        textline "       "
        bitfld.long 0x00 5. " WB_SWAP ,Swap bytes in words." "0,1"
        textline "       "
        hexmask.long.byte 0x00 8.--10. 1. " DECY ,Verticle pre decimation filter control."
        textline "       "
        hexmask.long.byte 0x00 10.--12. 1. " DECX ,Horizontal pre decimation filter control."
width 7.
group.long 0xc0++0x3
    line.long 0x00 "PS_BUF,PS Input Buffer Address"
        hexmask.long.long 0x00 0.--32. 1. " ADDR ,Address pointer for the PS RGB or Y (luma) input buffer."
width 8.
group.long 0xd0++0x3
    line.long 0x00 "PS_UBUF,PS U/Cb or 2 Plane UV Input Buffer Address"
        hexmask.long.long 0x00 0.--32. 1. " ADDR ,Address pointer for the PS U/Cb or 2 plane UV Chroma input buffer."
width 8.
group.long 0xe0++0x3
    line.long 0x00 "PS_VBUF,PS V/Cr Input Buffer Address"
        hexmask.long.long 0x00 0.--32. 1. " ADDR ,Address pointer for the PS V/Cr Chroma input buffer."
width 9.
group.long 0xf0++0x3
    line.long 0x00 "PS_PITCH,Processed Surface Pitch"
        hexmask.long.word 0x00 0.--16. 1. " PITCH ,Indicates the number of bytes in memory between two vertically adjacent pixels."
width 14.
group.long 0x100++0x3
    line.long 0x00 "PS_BACKGROUND,PS Background Color"
        hexmask.long.long 0x00 0.--24. 1. " COLOR ,Background color (in 24bpp format) for any pixels not within the buffer range specified by the PS ULC/LRC."
width 9.
group.long 0x110++0x3
    line.long 0x00 "PS_SCALE,PS Scale Factor Register"
        hexmask.long.word 0x00 0.--15. 1. " XSCALE ,This is a two bit integer and 12 bit fractional representation (##.####_####_####) of the X scaling factor for the PS source buffer."
        textline "        "
        hexmask.long.word 0x00 16.--31. 1. " YSCALE ,This is a two bit integer and 12 bit fractional representation (##.####_####_####) of the Y scaling factor for the PS source buffer."
width 10.
group.long 0x120++0x3
    line.long 0x00 "PS_OFFSET,PS Scale Offset Register"
        hexmask.long.word 0x00 0.--12. 1. " XOFFSET ,This is a 12 bit fractional representation (0.####_####_####) of the X scaling offset."
        textline "         "
        hexmask.long.word 0x00 16.--28. 1. " YOFFSET ,This is a 12 bit fractional representation (0.####_####_####) of the Y scaling offset."
width 13.
group.long 0x130++0x3
    line.long 0x00 "PS_CLRKEYLOW,PS Color Key Low"
        hexmask.long.long 0x00 0.--24. 1. " PIXEL ,Low range of color key applied to PS buffer."
width 14.
group.long 0x140++0x3
    line.long 0x00 "PS_CLRKEYHIGH,PS Color Key High"
        hexmask.long.long 0x00 0.--24. 1. " PIXEL ,High range of color key applied to PS buffer."
width 8.
group.long 0x150++0x3
    line.long 0x00 "AS_CTRL,Alpha Surface Control"
        hexmask.long.byte 0x00 1.--3. 1. " ALPHA_CTRL ,Determines how the alpha value is constructed for this alpha surface."
        textline "       "
        bitfld.long 0x00 3. " ENABLE_COLORKEY ,Indicates that colorkey functionality is enabled for this alpha surface." "0,1"
        textline "       "
        hexmask.long.byte 0x00 4.--8. 1. " FORMAT ,Indicates the input buffer format for AS."
        textline "       "
        hexmask.long.byte 0x00 8.--16. 1. " ALPHA ,Alpha modifier used when the ALPHA_MULTIPLY or ALPHA_OVERRIDE values are programmed in PXP_AS_CTRL[ALPHA_CTRL]."
        textline "       "
        hexmask.long.byte 0x00 16.--20. 1. " ROP ,Indicates a raster operation to perform when enabled."
        textline "       "
        bitfld.long 0x00 20. " ALPHA_INVERT ,Setting this bit to logic 0 will not alter the alpha value." "0,1"
width 7.
group.long 0x160++0x3
    line.long 0x00 "AS_BUF,Alpha Surface Buffer Pointer"
        hexmask.long.long 0x00 0.--32. 1. " ADDR ,Address pointer for the alpha surface 0 buffer."
width 9.
group.long 0x170++0x3
    line.long 0x00 "AS_PITCH,Alpha Surface Pitch"
        hexmask.long.word 0x00 0.--16. 1. " PITCH ,Indicates the number of bytes in memory between two vertically adjacent pixels."
width 13.
group.long 0x180++0x3
    line.long 0x00 "AS_CLRKEYLOW,Overlay Color Key Low"
        hexmask.long.long 0x00 0.--24. 1. " PIXEL ,Low range of RGB color key applied to AS buffer."
width 14.
group.long 0x190++0x3
    line.long 0x00 "AS_CLRKEYHIGH,Overlay Color Key High"
        hexmask.long.long 0x00 0.--24. 1. " PIXEL ,High range of RGB color key applied to AS buffer."
width 11.
group.long 0x1a0++0x3
    line.long 0x00 "CSC1_COEF0,Color Space Conversion Coefficient Register 0"
        hexmask.long.word 0x00 0.--9. 1. " Y_OFFSET ,Two's compliment amplitude offset implicit in the Y data."
        textline "          "
        hexmask.long.word 0x00 9.--18. 1. " UV_OFFSET ,Two's compliment phase offset implicit for CbCr data."
        textline "          "
        hexmask.long.word 0x00 18.--29. 1. " C0 ,Two's compliment Y multiplier coefficient."
        textline "          "
        bitfld.long 0x00 30. " BYPASS ,Bypass the CSC unit in the scaling engine." "0,1"
        textline "          "
        bitfld.long 0x00 31. " YCBCR_MODE ,Set to 1 when performing YCbCr conversion to RGB." "0,1"
width 11.
group.long 0x1b0++0x3
    line.long 0x00 "CSC1_COEF1,Color Space Conversion Coefficient Register 1"
        hexmask.long.word 0x00 0.--11. 1. " C4 ,Two's compliment Blue U/Cb multiplier coefficient."
        textline "          "
        hexmask.long.word 0x00 16.--27. 1. " C1 ,Two's compliment Red V/Cr multiplier coefficient."
width 11.
group.long 0x1c0++0x3
    line.long 0x00 "CSC1_COEF2,Color Space Conversion Coefficient Register 2"
        hexmask.long.word 0x00 0.--11. 1. " C3 ,Two's complement Green U/Cb multiplier coefficient."
        textline "          "
        hexmask.long.word 0x00 16.--27. 1. " C2 ,Two's complement Green V/Cr multiplier coefficient."
width 10.
group.long 0x1d0++0x3
    line.long 0x00 "CSC2_CTRL,Color Space Conversion Control Register."
        bitfld.long 0x00 0. " BYPASS ,This bit controls whether the pixels entering the CSC2 unit get converted or not." "0,1"
        textline "         "
        hexmask.long.byte 0x00 1.--3. 1. " CSC_MODE ,This field controls how the CSC unit operates on pixels when the CSC is not bypassed."
width 11.
group.long 0x1e0++0x3
    line.long 0x00 "CSC2_COEF0,Color Space Conversion Coefficient Register 0"
        hexmask.long.word 0x00 0.--11. 1. " A1 ,Two's complement coefficient offset."
        textline "          "
        hexmask.long.word 0x00 16.--27. 1. " A2 ,Two's complement coefficient offset."
width 11.
group.long 0x1f0++0x3
    line.long 0x00 "CSC2_COEF1,Color Space Conversion Coefficient Register 1"
        hexmask.long.word 0x00 0.--11. 1. " A3 ,Two's complement coefficient offset."
        textline "          "
        hexmask.long.word 0x00 16.--27. 1. " B1 ,Two's complement coefficient offset."
width 11.
group.long 0x200++0x3
    line.long 0x00 "CSC2_COEF2,Color Space Conversion Coefficient Register 2"
        hexmask.long.word 0x00 0.--11. 1. " B2 ,Two's complement coefficient offset."
        textline "          "
        hexmask.long.word 0x00 16.--27. 1. " B3 ,Two's complement coefficient offset."
width 11.
group.long 0x210++0x3
    line.long 0x00 "CSC2_COEF3,Color Space Conversion Coefficient Register 3"
        hexmask.long.word 0x00 0.--11. 1. " C1 ,Two's complement coefficient offset."
        textline "          "
        hexmask.long.word 0x00 16.--27. 1. " C2 ,Two's complement coefficient offset."
width 11.
group.long 0x220++0x3
    line.long 0x00 "CSC2_COEF4,Color Space Conversion Coefficient Register 4"
        hexmask.long.word 0x00 0.--11. 1. " C3 ,Two's complement coefficient offset."
        textline "          "
        hexmask.long.word 0x00 16.--25. 1. " D1 ,Two's complement coefficient integer offset to be added."
width 11.
group.long 0x230++0x3
    line.long 0x00 "CSC2_COEF5,Color Space Conversion Coefficient Register 5"
        hexmask.long.word 0x00 0.--9. 1. " D2 ,Two's complement D1 coefficient integer offset to be added."
        textline "          "
        hexmask.long.word 0x00 16.--25. 1. " D3 ,Two's complement coefficient integer offset to be added."
width 9.
group.long 0x240++0x3
    line.long 0x00 "LUT_CTRL,Lookup Table Control Register."
        bitfld.long 0x00 0. " DMA_START ,Setting this bit will result in the DMA operation to load the PXP LUT memory based on PXP_LUT_ADDR_NUM_BYTES, PXP_LUT_ADDR_ADDR, and PXP_LUT_MEM_ADDR." "0,1"
        textline "        "
        bitfld.long 0x00 8. " INVALID ,Invalidate the cache LRU and valid bits." "0,1"
        textline "        "
        bitfld.long 0x00 9. " LRU_UPD ,Least Recently Used Policy Update Control: 1=> block LRU update for hit after miss." "0,1"
        textline "        "
        bitfld.long 0x00 10. " SEL_8KB ,Selects which 8KB bank of memory to use for direct 12bpp lookup modes." "0,1"
        textline "        "
        hexmask.long.byte 0x00 16.--18. 1. " OUT_MODE ,Select the output mode of operation for the LUT resource."
        textline "        "
        hexmask.long.byte 0x00 24.--26. 1. " LOOKUP_MODE ,Configure the input address for the 16KB LUT memory."
        textline "        "
        bitfld.long 0x00 31. " BYPASS ,Setting this bit will bypass the LUT memory resource completely." "0,1"
width 9.
group.long 0x250++0x3
    line.long 0x00 "LUT_ADDR,Lookup Table Control Register."
        hexmask.long.word 0x00 0.--14. 1. " ADDR ,LUT indexed address pointer."
        textline "        "
        hexmask.long.word 0x00 16.--31. 1. " NUM_BYTES ,Indicates the number of bytes to load via a DMA operation."
width 9.
group.long 0x260++0x3
    line.long 0x00 "LUT_DATA,Lookup Table Data Register."
        hexmask.long.long 0x00 0.--32. 1. " DATA ,Writing this field will load 4 bytes, aligned to four byte boundaries, of data indexed by the ADDR field of the PXP_LUT_CTRL register."
width 11.
group.long 0x270++0x3
    line.long 0x00 "LUT_EXTMEM,Lookup Table External Memory Address Register."
        hexmask.long.long 0x00 0.--32. 1. " ADDR ,This register contains the external memory address used for LUT memory operation."
width 4.
group.long 0x280++0x3
    line.long 0x00 "CFA,Color Filter Array Register."
        hexmask.long.long 0x00 0.--32. 1. " DATA ,This register contains the Color Filter Array pattern for decimation of RGBW4444 16 bit pixels to individual R, G, B, W values."
width 10.
group.long 0x290++0x3
    line.long 0x00 "HIST_CTRL,Histogram Control Register."
        hexmask.long.byte 0x00 0.--4. 1. " STATUS ,Indicates which histogram matched the processed bitmap."
        textline "         "
        hexmask.long.byte 0x00 4.--6. 1. " PANEL_MODE ,Specifies the EPDC panel grayscale depth."
width 12.
group.long 0x2a0++0x3
    line.long 0x00 "HIST2_PARAM,2-level Histogram Parameter Register."
        hexmask.long.byte 0x00 0.--5. 1. " VALUE0 ,Black value for 2-level histogram"
        textline "           "
        hexmask.long.byte 0x00 8.--13. 1. " VALUE1 ,White value for 2-level histogram"
width 12.
group.long 0x2b0++0x3
    line.long 0x00 "HIST4_PARAM,4-level Histogram Parameter Register."
        hexmask.long.byte 0x00 0.--5. 1. " VALUE0 ,GRAY0 (Black) value for 4-level histogram"
        textline "           "
        hexmask.long.byte 0x00 8.--13. 1. " VALUE1 ,GRAY1 value for 4-level histogram"
        textline "           "
        hexmask.long.byte 0x00 16.--21. 1. " VALUE2 ,GRAY2 value for 4-level histogram"
        textline "           "
        hexmask.long.byte 0x00 24.--29. 1. " VALUE3 ,GRAY3 (White) value for 4-level histogram"
width 13.
group.long 0x2c0++0x3
    line.long 0x00 "HIST8_PARAM0,8-level Histogram Parameter 0 Register."
        hexmask.long.byte 0x00 0.--5. 1. " VALUE0 ,GRAY0 (Black) value for 8-level histogram"
        textline "            "
        hexmask.long.byte 0x00 8.--13. 1. " VALUE1 ,GRAY1 value for 8-level histogram"
        textline "            "
        hexmask.long.byte 0x00 16.--21. 1. " VALUE2 ,GRAY2 value for 8-level histogram"
        textline "            "
        hexmask.long.byte 0x00 24.--29. 1. " VALUE3 ,GRAY3 value for 8-level histogram"
width 13.
group.long 0x2d0++0x3
    line.long 0x00 "HIST8_PARAM1,8-level Histogram Parameter 1 Register."
        hexmask.long.byte 0x00 0.--5. 1. " VALUE4 ,GRAY4 value for 8-level histogram"
        textline "            "
        hexmask.long.byte 0x00 8.--13. 1. " VALUE5 ,GRAY5 value for 8-level histogram"
        textline "            "
        hexmask.long.byte 0x00 16.--21. 1. " VALUE6 ,GRAY6 value for 8-level histogram"
        textline "            "
        hexmask.long.byte 0x00 24.--29. 1. " VALUE7 ,GRAY7 (White) value for 8-level histogram"
width 14.
group.long 0x2e0++0x3
    line.long 0x00 "HIST16_PARAM0,16-level Histogram Parameter 0 Register."
        hexmask.long.byte 0x00 0.--5. 1. " VALUE0 ,GRAY0 (Black) value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 8.--13. 1. " VALUE1 ,GRAY1 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 16.--21. 1. " VALUE2 ,GRAY2 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 24.--29. 1. " VALUE3 ,GRAY3 value for 16-level histogram"
width 14.
group.long 0x2f0++0x3
    line.long 0x00 "HIST16_PARAM1,16-level Histogram Parameter 1 Register."
        hexmask.long.byte 0x00 0.--5. 1. " VALUE4 ,GRAY4 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 8.--13. 1. " VALUE5 ,GRAY5 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 16.--21. 1. " VALUE6 ,GRAY6 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 24.--29. 1. " VALUE7 ,GRAY7 value for 16-level histogram"
width 14.
group.long 0x300++0x3
    line.long 0x00 "HIST16_PARAM2,16-level Histogram Parameter 2 Register."
        hexmask.long.byte 0x00 0.--5. 1. " VALUE8 ,GRAY8 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 8.--13. 1. " VALUE9 ,GRAY9 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 16.--21. 1. " VALUE10 ,GRAY10 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 24.--29. 1. " VALUE11 ,GRAY11 value for 16-level histogram"
width 14.
group.long 0x310++0x3
    line.long 0x00 "HIST16_PARAM3,16-level Histogram Parameter 3 Register."
        hexmask.long.byte 0x00 0.--5. 1. " VALUE12 ,GRAY12 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 8.--13. 1. " VALUE13 ,GRAY13 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 16.--21. 1. " VALUE14 ,GRAY14 value for 16-level histogram"
        textline "             "
        hexmask.long.byte 0x00 24.--29. 1. " VALUE15 ,GRAY15 (White) value for 16-level histogram"
width 6.
group.long 0x320++0x3
    line.long 0x00 "POWER,PXP Power Control Register."
        hexmask.long.byte 0x00 0.--3. 1. " LUT_LP_STATE_WAY0_BANK0 ,Select the low power state of the LUT's WAY0-BANK0 memory."
        textline "     "
        hexmask.long.byte 0x00 3.--6. 1. " LUT_LP_STATE_WAY0_BANKN ,Select the low power state of the LUT's WAY0-BANK1,2,3 memory."
        textline "     "
        hexmask.long.byte 0x00 6.--9. 1. " LUT_LP_STATE_WAY1_BANKN ,Select the low power state of the LUT's WAY0-BANK0,1,2,3 memory."
        textline "     "
        hexmask.long.byte 0x00 9.--12. 1. " ROT_MEM_LP_STATE ,Select the low power state of the ROT memory."
        textline "     "
        hexmask.long.long 0x00 12.--32. 1. " CTRL ,This register contains power control for the PXP."
width 5.
group.long 0x400++0x3
    line.long 0x00 "NEXT,Next Frame Pointer"
        bitfld.long 0x00 0. " ENABLED ,Indicates that the ""next frame"" functionality has been enabled." "0,1"
        textline "    "
        hexmask.long.long 0x00 2.--32. 1. " POINTER ,A pointer to a data structure containing register values to be used when processing the next frame."


tree.end



;--------------------------------------------------------------------------------
; QOS
;--------------------------------------------------------------------------------
tree "QOS"
    base ad:0x02094000

width 5.
group.long 0x0++0x3
    line.long 0x00 "CTRL,QOS Control Register"
        bitfld.long 0x00 0. " EMI_PRIORITY_MODE ,Set this bit to one to enable QoS and priority values to be set separately for the AXI fabric and EMI." "0,1"
        textline "    "
        bitfld.long 0x00 1. " XLATE_AXI_MODE ,This bit selects the way in which AXI QoS information is translated into EMI priority values." "0,1"
        textline "    "
        hexmask.long.byte 0x00 2.--4. 1. " EPDC_PRIORITY_BOOST ,Set this field to enable a feedback path that allows the EPDC to request higher priority for its accesses when needed."
        textline "    "
        hexmask.long.byte 0x00 4.--6. 1. " LCDIF_PRIORITY_BOOST ,Set this field to enable a feedback path that allows the eLCDIF to request higher priority for its accesses when needed."
        textline "    "
        bitfld.long 0x00 30. " CLKGATE ,This bit must be set to zero for normal operation." "0,1"
        textline "    "
        bitfld.long 0x00 31. " SFTRST ,Set to zero for normal operation." "0,1"
width 9.
group.long 0x10++0x3
    line.long 0x00 "AXI_QOS0,AXI QOS Register"
        hexmask.long.byte 0x00 0.--3. 1. " M0_AWQOS ,Specifies the QOS level for the write commands on MasterID 0."
        textline "        "
        hexmask.long.byte 0x00 4.--7. 1. " M0_ARQOS ,Specifies the QOS level for the read commands on MasterID 0."
        textline "        "
        hexmask.long.byte 0x00 8.--11. 1. " M1_0_AWQOS ,Specifies the QOS level for the write commands on MasterID 1."
        textline "        "
        hexmask.long.byte 0x00 12.--15. 1. " M1_0_ARQOS ,Specifies the QOS level for the read commands on MasterID 1."
        textline "        "
        hexmask.long.byte 0x00 16.--19. 1. " M1_1_AWQOS ,Specifies the QOS level for the write commands on MasterID 2."
        textline "        "
        hexmask.long.byte 0x00 20.--23. 1. " M1_1_ARQOS ,Specifies the QOS level for the read commands on MasterID 2."
        textline "        "
        hexmask.long.byte 0x00 24.--27. 1. " M1_2_AWQOS ,Specifies the QOS level for the write commands on MasterID 3."
        textline "        "
        hexmask.long.byte 0x00 28.--31. 1. " M1_2_ARQOS ,Specifies the QOS level for the read commands on MasterID 3."
width 9.
group.long 0x20++0x3
    line.long 0x00 "AXI_QOS1,AXI QOS Register"
        hexmask.long.byte 0x00 0.--3. 1. " M2_AWQOS ,Specifies the QOS level for the write commands on MasterID 4."
        textline "        "
        hexmask.long.byte 0x00 4.--7. 1. " M2_ARQOS ,Specifies the QOS level for the read commands on MasterID 4."
        textline "        "
        hexmask.long.byte 0x00 8.--11. 1. " M3_AWQOS ,Specifies the QOS level for the write commands on MasterID 5."
        textline "        "
        hexmask.long.byte 0x00 12.--15. 1. " M3_ARQOS ,Specifies the QOS level for the read commands on MasterID 5."
        textline "        "
        hexmask.long.byte 0x00 16.--19. 1. " M4_AWQOS ,Specifies the QOS level for the write commands on MasterID 6."
        textline "        "
        hexmask.long.byte 0x00 20.--23. 1. " M4_ARQOS ,Specifies the QOS level for the read commands on MasterID 6."
        textline "        "
        hexmask.long.byte 0x00 24.--27. 1. " M5_AWQOS ,Specifies the QOS level for the write commands on MasterID 7."
        textline "        "
        hexmask.long.byte 0x00 28.--31. 1. " M5_ARQOS ,Specifies the QOS level for the read commands on MasterID 7."
width 9.
group.long 0x30++0x3
    line.long 0x00 "AXI_QOS2,AXI QOS Register"
        hexmask.long.byte 0x00 0.--3. 1. " M6_AWQOS ,Specifies the QOS level for the write commands on MasterID 8."
        textline "        "
        hexmask.long.byte 0x00 4.--7. 1. " M6_ARQOS ,Specifies the QOS level for the read commands on MasterID 8."
        textline "        "
        hexmask.long.byte 0x00 8.--11. 1. " M7_AWQOS ,Specifies the QOS level for the write commands on MasterID 9."
        textline "        "
        hexmask.long.byte 0x00 12.--15. 1. " M7_ARQOS ,Specifies the QOS level for the read commands on MasterID 9."
        textline "        "
        hexmask.long.byte 0x00 16.--19. 1. " M8_AWQOS ,Specifies the QOS level for the write commands on MasterID 10."
        textline "        "
        hexmask.long.byte 0x00 20.--23. 1. " M8_ARQOS ,Specifies the QOS level for the read commands on MasterID 10."
        textline "        "
        hexmask.long.byte 0x00 24.--27. 1. " M9_AWQOS ,Specifies the QOS level for the write commands on MasterID 10."
        textline "        "
        hexmask.long.byte 0x00 28.--31. 1. " M9_ARQOS ,Specifies the QOS level for the read commands on MasterID 11."
width 14.
group.long 0x40++0x3
    line.long 0x00 "EMI_PRIORITY0,EMI priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " M0_WR ,Specifies the priority level for the write commands on MasterID 0."
        textline "             "
        hexmask.long.byte 0x00 4.--7. 1. " M0_RD ,Specifies the priority level for the read commands on MasterID 0."
        textline "             "
        hexmask.long.byte 0x00 8.--11. 1. " M1_0_WR ,Specifies the priority level for the write commands on MasterID 1."
        textline "             "
        hexmask.long.byte 0x00 12.--15. 1. " M1_0_RD ,Specifies the priority level for the read commands on MasterID 1."
        textline "             "
        hexmask.long.byte 0x00 16.--19. 1. " M1_1_WR ,Specifies the priority level for the write commands on MasterID 2."
        textline "             "
        hexmask.long.byte 0x00 20.--23. 1. " M1_1_RD ,Specifies the priority level for the read commands on MasterID 2."
        textline "             "
        hexmask.long.byte 0x00 24.--27. 1. " M1_2_WR ,Specifies the priority level for the write commands on MasterID 3."
        textline "             "
        hexmask.long.byte 0x00 28.--31. 1. " M1_2_RD ,Specifies the priority level for the read commands on MasterID 3."
width 14.
group.long 0x50++0x3
    line.long 0x00 "EMI_PRIORITY1,EMI priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " M2_WR ,Specifies the priority level for the write commands on MasterID 4."
        textline "             "
        hexmask.long.byte 0x00 4.--7. 1. " M2_RD ,Specifies the priority level for the read commands on MasterID 4."
        textline "             "
        hexmask.long.byte 0x00 8.--11. 1. " M3_WR ,Specifies the priority level for the write commands on MasterID 5."
        textline "             "
        hexmask.long.byte 0x00 12.--15. 1. " M3_RD ,Specifies the priority level for the read commands on MasterID 5."
        textline "             "
        hexmask.long.byte 0x00 16.--19. 1. " M4_WR ,Specifies the priority level for the write commands on MasterID 6."
        textline "             "
        hexmask.long.byte 0x00 20.--23. 1. " M4_RD ,Specifies the priority level for the read commands on MasterID 6."
        textline "             "
        hexmask.long.byte 0x00 24.--27. 1. " M5_WR ,Specifies the priority level for the write commands on MasterID 7."
        textline "             "
        hexmask.long.byte 0x00 28.--31. 1. " M5_RD ,Specifies the priority level for the read commands on MasterID 7."
width 14.
group.long 0x60++0x3
    line.long 0x00 "EMI_PRIORITY2,EMI priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " M6_WR ,Specifies the priority level for the write commands on MasterID 8."
        textline "             "
        hexmask.long.byte 0x00 4.--7. 1. " M6_RD ,Specifies the priority level for the read commands on MasterID 8."
        textline "             "
        hexmask.long.byte 0x00 8.--11. 1. " M7_WR ,Specifies the priority level for the write commands on MasterID 9."
        textline "             "
        hexmask.long.byte 0x00 12.--15. 1. " M7_RD ,Specifies the priority level for the read commands on MasterID 9."
        textline "             "
        hexmask.long.byte 0x00 16.--19. 1. " M8_WR ,Specifies the priority level for the write commands on MasterID 10."
        textline "             "
        hexmask.long.byte 0x00 20.--23. 1. " M8_RD ,Specifies the priority level for the read commands on MasterID 10."
        textline "             "
        hexmask.long.byte 0x00 24.--27. 1. " M9_WR ,Specifies the priority level for the write commands on MasterID 10."
        textline "             "
        hexmask.long.byte 0x00 28.--31. 1. " M9_RD ,Specifies the priority level for the read commands on MasterID 11."
width 8.
group.long 0x70++0x3
    line.long 0x00 "DISABLE,AXI Master Disble Register"
        bitfld.long 0x00 1. " M1_0_DIS ,Setting this bit disables the interface between master1_0 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 2. " M1_1_DIS ,Setting this bit disables the interface between master1_1 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 3. " M1_2_DIS ,Setting this bit disables the interface between master1_2 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 4. " M2_DIS ,Setting this bit disables the interface between master2 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 5. " M3_DIS ,Setting this bit disables the interface between master3 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 6. " M4_DIS ,Setting this bit disables the interface between master4 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 7. " M5_DIS ,Setting this bit disables the interface between master5 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 8. " M6_DIS ,Setting this bit disables the interface between master6 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 9. " M7_DIS ,Setting this bit disables the interface between master7 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 10. " M8_DIS ,Setting this bit disables the interface between master8 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 11. " M9_DIS ,Setting this bit disables the interface between master9 and the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 17. " M1_0_DIS_STAT ,This bit indicates the enable/disable status for master port1_0 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 18. " M1_1_DIS_STAT ,This bit indicates the enable/disable status for master port1_1 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 19. " M1_2_DIS_STAT ,This bit indicates the enable/disable status for master port1_2 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 20. " M2_DIS_STAT ,This bit indicates the enable/disable status for master port0 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 21. " M3_DIS_STAT ,This bit indicates the enable/disable status for master port0 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 22. " M4_DIS_STAT ,This bit indicates the enable/disable status for master port0 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 23. " M5_DIS_STAT ,This bit indicates the enable/disable status for master port0 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 24. " M6_DIS_STAT ,This bit indicates the enable/disable status for master port0 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 25. " M7_DIS_STAT ,This bit indicates the enable/disable status for master port0 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 26. " M8_DIS_STAT ,This bit indicates the enable/disable status for master port0 on the AXI fabric." "0,1"
        textline "       "
        bitfld.long 0x00 27. " M9_DIS_STAT ,This bit indicates the enable/disable status for master port0 on the AXI fabric." "0,1"
width 8.
rgroup.long 0x80++0x3
    line.long 0x00 "VERSION,QOS Version Register"
        hexmask.long.word 0x00 0.--16. 1. " STEP ,Fixed read-only value reflecting the stepping of the RTL version."
        textline "       "
        hexmask.long.byte 0x00 16.--24. 1. " MINOR ,Fixed read-only value reflecting the MINOR field of the RTL version."
        textline "       "
        hexmask.long.byte 0x00 24.--32. 1. " MAJOR ,Fixed read-only value reflecting the MAJOR field of the RTL version."


tree.end



;--------------------------------------------------------------------------------
; RNG
;--------------------------------------------------------------------------------
tree "RNG"
    base ad:0x021b4000

width 4.
rgroup.long 0x0++0x3
    line.long 0x00 "VER,RNGB Version ID Register"
        hexmask.long.byte 0x00 0.--8. 1. " MINOR ,Subjiect to change."
        textline "   "
        hexmask.long.byte 0x00 8.--16. 1. " MAJOR ,This field is always set to 0x02."
        textline "   "
        hexmask.long.byte 0x00 28.--32. 1. " TYPE ,"
width 4.
group.long 0x4++0x3
    line.long 0x00 "CMD,RNGB Command Register"
        bitfld.long 0x00 0. " ST ,Initiates a self test of the RNGB's internal logic." "0,1"
        textline "   "
        bitfld.long 0x00 1. " GS ,Initiates the seed generation process." "0,1"
        textline "   "
        bitfld.long 0x00 4. " CI ,Clears the RNGB interrupt if an error is not present." "0,1"
        textline "   "
        bitfld.long 0x00 5. " CE ,Clears the errors in the RNG_ESR register and the RNGB interrupt.This bit is self-clearing." "0,1"
        textline "   "
        bitfld.long 0x00 6. " SR ,Performs a software reset of the RNGB." "0,1"
width 3.
group.long 0x8++0x3
    line.long 0x00 "CR,RNGB Control Register"
        hexmask.long.byte 0x00 0.--2. 1. " FUFMOD ,Controls the RNGB's response to a FIFO underflow condition."
        textline "  "
        bitfld.long 0x00 4. " AR ,Setting this bit allows the RNGB to automatically generate a new seed whenever one is needed." "0,1"
        textline "  "
        bitfld.long 0x00 5. " MASKDONE ,Masks interrupts generated upon completion of seed and self test modes." "0,1"
        textline "  "
        bitfld.long 0x00 6. " MASKERR ,Masks interrupts generated by errors in the RNGB." "0,1"
width 3.
rgroup.long 0xc++0x3
    line.long 0x00 "SR,RNGB Status Register"
        bitfld.long 0x00 1. " BUSY ,Reflects the current state of RNGB." "0,1"
        textline "  "
        bitfld.long 0x00 2. " SLP ,Indicates if the RNGB is in sleep mode." "0,1"
        textline "  "
        bitfld.long 0x00 3. " RS ,Indicates the RNGB needs to be reseeded." "0,1"
        textline "  "
        bitfld.long 0x00 4. " STDN ,Indicates the self test is complete." "0,1"
        textline "  "
        bitfld.long 0x00 5. " SDN ,Indicates the RNG has generated the first seed." "0,1"
        textline "  "
        bitfld.long 0x00 6. " NSDN ,Indicates that a new seed is ready for use during the next seed generation process." "0,1"
        textline "  "
        hexmask.long.byte 0x00 8.--12. 1. " FIFO_LVL ,Indicates the number of random words currently in the output FIFO."
        textline "  "
        hexmask.long.byte 0x00 12.--16. 1. " FIFO_SIZE ,Size of the FIFO, and maximum possible FIFO level."
        textline "  "
        bitfld.long 0x00 16. " ERR ,Indicates an error was detected in the RNGB." "0,1"
        textline "  "
        hexmask.long.byte 0x00 21.--24. 1. " ST_PF ,Indicates Pass or Fail status of the TRNG, PRNG, and RESEED self tests, Bit 23 - TRNG self test pass/fail Bit 22 - PRNG self test pass/fail Bit 21 - RESEED self test pass/fail"
        textline "  "
        hexmask.long.byte 0x00 24.--32. 1. " STATPF ,Indicates pass or fail status of the various statistics tests on the last seed generated."
width 4.
rgroup.long 0x10++0x3
    line.long 0x00 "ESR,RNGB Error Status Register"
        bitfld.long 0x00 0. " LFE ,When this bit is set, the interrupt generated was caused by a failure of one of the LFSRs in one of the RNGB's three entropy sources." "0,1"
        textline "   "
        bitfld.long 0x00 1. " OSCE ,Indicates the oscillator in the RNG may be broken." "0,1"
        textline "   "
        bitfld.long 0x00 2. " STE ,Indicates the RNGB has failed the most recent self test." "0,1"
        textline "   "
        bitfld.long 0x00 3. " SATE ,Indicates if RNGB has failed the statistical tests for the last generated seed." "0,1"
        textline "   "
        bitfld.long 0x00 4. " FUFE ,Indicates the RNGB has experienced a FIFO underflow condition resulting in the last random data read being unreliable." "0,1"
width 4.
rgroup.long 0x14++0x3
    line.long 0x00 "OUT,RNGB Output FIFO"
        hexmask.long.long 0x00 0.--32. 1. " RANDOUT ,"


tree.end



;--------------------------------------------------------------------------------
; ROMC
;--------------------------------------------------------------------------------
tree "ROMC"
    base ad:0x021ac000

width 11.
group.long 0xd4++0x3
    line.long 0x00 "ROMPATCH0D,ROMC Data Registers"
        hexmask.long.long 0x00 0.--32. 1. " DATAX ,Data Fix Registers - Stores the data used for 1-word data fix operations."
width 11.
group.long 0xd8++0x3
    line.long 0x00 "ROMPATCH1D,ROMC Data Registers"
        hexmask.long.long 0x00 0.--32. 1. " DATAX ,Data Fix Registers - Stores the data used for 1-word data fix operations."
width 11.
group.long 0xdc++0x3
    line.long 0x00 "ROMPATCH2D,ROMC Data Registers"
        hexmask.long.long 0x00 0.--32. 1. " DATAX ,Data Fix Registers - Stores the data used for 1-word data fix operations."
width 11.
group.long 0xe0++0x3
    line.long 0x00 "ROMPATCH3D,ROMC Data Registers"
        hexmask.long.long 0x00 0.--32. 1. " DATAX ,Data Fix Registers - Stores the data used for 1-word data fix operations."
width 11.
group.long 0xe4++0x3
    line.long 0x00 "ROMPATCH4D,ROMC Data Registers"
        hexmask.long.long 0x00 0.--32. 1. " DATAX ,Data Fix Registers - Stores the data used for 1-word data fix operations."
width 11.
group.long 0xe8++0x3
    line.long 0x00 "ROMPATCH5D,ROMC Data Registers"
        hexmask.long.long 0x00 0.--32. 1. " DATAX ,Data Fix Registers - Stores the data used for 1-word data fix operations."
width 11.
group.long 0xec++0x3
    line.long 0x00 "ROMPATCH6D,ROMC Data Registers"
        hexmask.long.long 0x00 0.--32. 1. " DATAX ,Data Fix Registers - Stores the data used for 1-word data fix operations."
width 11.
group.long 0xf0++0x3
    line.long 0x00 "ROMPATCH7D,ROMC Data Registers"
        hexmask.long.long 0x00 0.--32. 1. " DATAX ,Data Fix Registers - Stores the data used for 1-word data fix operations."
width 13.
group.long 0xf4++0x3
    line.long 0x00 "ROMPATCHCNTL,ROMC Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " DATAFIX ,Data Fix Enable - Controls the use of the first 8 address comparators for 1-word data fix or for code patch routine."
        textline "            "
        bitfld.long 0x00 29. " DIS ,ROMC Disable -- This bit, when set, disables all ROMC operations." "0,1"
width 12.
rgroup.long 0xf8++0x3
    line.long 0x00 "ROMPATCHENH,ROMC Enable Register High"
width 12.
group.long 0xfc++0x3
    line.long 0x00 "ROMPATCHENL,ROMC Enable Register Low"
        hexmask.long.word 0x00 0.--16. 1. " ENABLE ,Enable Address Comparator - This bit enables the corresponding address comparator to trigger an event."
width 11.
group.long 0x100++0x3
    line.long 0x00 "ROMPATCH0A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x104++0x3
    line.long 0x00 "ROMPATCH1A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x108++0x3
    line.long 0x00 "ROMPATCH2A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x10c++0x3
    line.long 0x00 "ROMPATCH3A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x110++0x3
    line.long 0x00 "ROMPATCH4A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x114++0x3
    line.long 0x00 "ROMPATCH5A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x118++0x3
    line.long 0x00 "ROMPATCH6A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x11c++0x3
    line.long 0x00 "ROMPATCH7A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x120++0x3
    line.long 0x00 "ROMPATCH8A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x124++0x3
    line.long 0x00 "ROMPATCH9A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "          "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 12.
group.long 0x128++0x3
    line.long 0x00 "ROMPATCH10A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "           "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 12.
group.long 0x12c++0x3
    line.long 0x00 "ROMPATCH11A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "           "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 12.
group.long 0x130++0x3
    line.long 0x00 "ROMPATCH12A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "           "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 12.
group.long 0x134++0x3
    line.long 0x00 "ROMPATCH13A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "           "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 12.
group.long 0x138++0x3
    line.long 0x00 "ROMPATCH14A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "           "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 12.
group.long 0x13c++0x3
    line.long 0x00 "ROMPATCH15A,ROMC Address Registers"
        bitfld.long 0x00 0. " THUMBX ,THUMB Comparator Select - Indicates that this address will trigger a THUMB opcode patch or an ARM opcode patch." "0,1"
        textline "           "
        hexmask.long.long 0x00 1.--23. 1. " ADDRX ,Address Comparator Registers - Indicates the memory address to be watched."
width 11.
group.long 0x208++0x3
    line.long 0x00 "ROMPATCHSR,ROMC Status Register"
        hexmask.long.byte 0x00 0.--6. 1. " SOURCE ,ROMC Source Number - Binary encoding of the number of the address comparator which has an address match in the most recent patch event on ROMC AHB."
        textline "          "
        bitfld.long 0x00 17. " SW ,ROMC AHB Multiple Address Comparator matches Indicator - Indicates that multiple address comparator matches occurred." "0,1"


tree.end



;--------------------------------------------------------------------------------
; SDMAARM
;--------------------------------------------------------------------------------
tree "SDMAARM"
    base ad:0x020ec000

width 7.
group.long 0x0++0x3
    line.long 0x00 "MC0PTR,ARM platform Channel 0 Pointer"
        hexmask.long.long 0x00 0.--32. 1. " MC0PTR ,Channel 0 Pointer contains the 32-bit address, in ARM platform memory, of channel 0 control block (the boot channel)."
width 5.
group.long 0x4++0x3
    line.long 0x00 "INTR,Channel Interrupts"
        hexmask.long.long 0x00 0.--32. 1. " HI ,The ARM platform Interrupts register contains the 32 HI[i] bits."
width 10.
group.long 0x8++0x3
    line.long 0x00 "STOP_STAT,Channel Stop/Channel Status"
        hexmask.long.long 0x00 0.--32. 1. " HE ,This 32-bit register gives access to the ARM platform Enable bits."
width 7.
group.long 0xc++0x3
    line.long 0x00 "HSTART,Channel Start"
        hexmask.long.long 0x00 0.--32. 1. " HSTART_HE ,The HSTART_HE registers are 32 bits wide with one bit for every channel."
width 7.
group.long 0x10++0x3
    line.long 0x00 "EVTOVR,Channel Event Override"
        hexmask.long.long 0x00 0.--32. 1. " EO ,The Channel Event Override register contains the 32 EO[i] bits."
width 7.
group.long 0x14++0x3
    line.long 0x00 "DSPOVR,Channel BP Override"
        hexmask.long.long 0x00 0.--32. 1. " DO ,This register is reserved."
width 8.
group.long 0x18++0x3
    line.long 0x00 "HOSTOVR,Channel ARM platform Override"
        hexmask.long.long 0x00 0.--32. 1. " HO ,The Channel ARM platform Override register contains the 32 HO[i] bits."
width 8.
group.long 0x1c++0x3
    line.long 0x00 "EVTPEND,Channel Event Pending"
        hexmask.long.long 0x00 0.--32. 1. " EP ,The Channel Event Pending register contains the 32 EP[i] bits."
width 6.
rgroup.long 0x24++0x3
    line.long 0x00 "RESET,Reset Register"
        bitfld.long 0x00 0. " RESET ,When set, this bit causes the SDMA to be held in a software reset." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RESCHED ,When set, this bit forces the SDMA to reschedule as if a script had executed a done instruction." "0,1"
width 7.
rgroup.long 0x28++0x3
    line.long 0x00 "EVTERR,DMA Request Error Register"
        hexmask.long.long 0x00 0.--32. 1. " CHNERR ,This register is used by the SDMA to warn the ARM platform when an incoming DMA request was detected and it triggers a channel that is already pending or being serviced."
width 9.
group.long 0x2c++0x3
    line.long 0x00 "INTRMASK,Channel ARM platform Interrupt Mask"
        hexmask.long.long 0x00 0.--32. 1. " HIMASK ,The Interrupt Mask Register contains 32 interrupt generation mask bits."
width 4.
rgroup.long 0x30++0x3
    line.long 0x00 "PSW,Schedule Status"
        hexmask.long.byte 0x00 0.--4. 1. " CCR ,The Current Channel Register indicates the number of the channel that is being executed by the SDMA."
        textline "   "
        hexmask.long.byte 0x00 4.--8. 1. " CCP ,The Current Channel Priority indicates the priority of the current active channel."
        textline "   "
        hexmask.long.byte 0x00 8.--13. 1. " NCR ,The Next Channel Register indicates the number of the next scheduled pending channel with the highest priority."
        textline "   "
        hexmask.long.byte 0x00 13.--16. 1. " NCP ,The Next Channel Priority gives the next pending channel priority."
width 10.
rgroup.long 0x34++0x3
    line.long 0x00 "EVTERRDBG,DMA Request Error Register"
        hexmask.long.long 0x00 0.--32. 1. " CHNERR ,This register is the same as EVTERR, except reading it does not clear its contents."
width 7.
group.long 0x38++0x3
    line.long 0x00 "CONFIG,Configuration Register"
        hexmask.long.byte 0x00 0.--2. 1. " CSM ,Selects the Context Switch Mode."
        textline "      "
        bitfld.long 0x00 4. " ACR ,ARM platform DMA / SDMA Core Clock Ratio." "0,1"
        textline "      "
        bitfld.long 0x00 11. " RTDOBS ,Indicates if Real-Time Debug pins are used: They do not toggle by default in order to reduce power consumption." "0,1"
        textline "      "
        bitfld.long 0x00 12. " DSPDMA ,This bit's function is reserved and should be configured as zero." "0,1"
width 10.
group.long 0x3c++0x3
    line.long 0x00 "SDMA_LOCK,SDMA LOCK"
        bitfld.long 0x00 0. " LOCK ,The LOCK bit is used to restrict access to update SDMA script memory through ROM channel zero scripts and through the OnCE interface under ARM platform control." "0,1"
        textline "         "
        bitfld.long 0x00 1. " SRESET_LOCK_CLR ,The SRESET_LOCK_CLR bit determine if the LOCK bit is cleared on a software reset triggered by writing to the RESET register." "0,1"
width 9.
group.long 0x40++0x3
    line.long 0x00 "ONCE_ENB,OnCE Enable"
        bitfld.long 0x00 0. " ENB ,The OnCE Enable register selects the OnCE control source: When cleared (0), the OnCE registers are accessed through the JTAG interface; when set (1), the OnCE registers may be accessed by the ARM platform through the addresses described, as follows." "0,1"
width 10.
group.long 0x44++0x3
    line.long 0x00 "ONCE_DATA,OnCE Data Register"
        hexmask.long.long 0x00 0.--32. 1. " DATA ,Data register of the OnCE JTAG controller."
width 11.
group.long 0x48++0x3
    line.long 0x00 "ONCE_INSTR,OnCE Instruction Register"
        hexmask.long.word 0x00 0.--16. 1. " INSTR ,Instruction register of the OnCE JTAG controller."
width 10.
rgroup.long 0x4c++0x3
    line.long 0x00 "ONCE_STAT,OnCE Status Register"
        hexmask.long.byte 0x00 0.--3. 1. " ECDR ,Event Cell Debug Request."
        textline "         "
        bitfld.long 0x00 7. " MST ,This flag is raised when the OnCE is controlled from the ARM platform peripheral interface." "0,1"
        textline "         "
        bitfld.long 0x00 8. " SWB ,This flag is raised when the SDMA has entered debug mode after a software breakpoint." "0,1"
        textline "         "
        bitfld.long 0x00 9. " ODR ,This flag is raised when the SDMA has entered debug mode after a OnCE debug request." "0,1"
        textline "         "
        bitfld.long 0x00 10. " EDR ,This flag is raised when the SDMA has entered debug mode after an external debug request." "0,1"
        textline "         "
        bitfld.long 0x00 11. " RCV ,After each write access to the real time buffer (RTB), the RCV bit is set." "0,1"
        textline "         "
        hexmask.long.byte 0x00 12.--16. 1. " PST ,The Processor Status bits reflect the state of the SDMA RISC engine."
width 9.
group.long 0x50++0x3
    line.long 0x00 "ONCE_CMD,OnCE Command Register"
        hexmask.long.byte 0x00 0.--4. 1. " CMD ,Writing to this register will cause the OnCE to execute the command that is written."
width 12.
group.long 0x58++0x3
    line.long 0x00 "ILLINSTADDR,Illegal Instruction Trap Address"
        hexmask.long.word 0x00 0.--14. 1. " ILLINSTADDR ,The Illegal Instruction Trap Address is the address where the SDMA jumps when an illegal instruction is executed."
width 9.
group.long 0x5c++0x3
    line.long 0x00 "CHN0ADDR,Channel 0 Boot Address"
        hexmask.long.word 0x00 0.--14. 1. " CHN0ADDR ,This 14-bit register is used by the boot code of the SDMA."
        textline "        "
        bitfld.long 0x00 14. " SMSZ ,The bit 14 (Scratch Memory Size) determines if scratch memory must be available after every channel context." "0,1"
width 11.
rgroup.long 0x60++0x3
    line.long 0x00 "EVT_MIRROR,DMA Requests"
        hexmask.long.long 0x00 0.--32. 1. " EVENTS ,This register reflects the DMA requests received by the SDMA for events 31-0."
width 12.
rgroup.long 0x64++0x3
    line.long 0x00 "EVT_MIRROR2,DMA Requests 2"
        hexmask.long.word 0x00 0.--16. 1. " EVENTS ,This register reflects the DMA requests received by the SDMA for events 47-32."
width 12.
group.long 0x70++0x3
    line.long 0x00 "XTRIG_CONF1,Cross-Trigger Events Configuration Register 1"
        hexmask.long.byte 0x00 0.--6. 1. " NUM0 ,Contains the number of the DMA request or channel that triggers the pulse on the cross-trigger event line number i ."
        textline "           "
        bitfld.long 0x00 6. " CNF0 ,Configuration of the SDMA event line number i that is connected to the cross-trigger." "0,1"
        textline "           "
        hexmask.long.byte 0x00 8.--14. 1. " NUM1 ,Contains the number of the DMA request or channel that triggers the pulse on the cross-trigger event line number i ."
        textline "           "
        bitfld.long 0x00 14. " CNF1 ,Configuration of the SDMA event line number i that is connected to the cross-trigger." "0,1"
        textline "           "
        hexmask.long.byte 0x00 16.--22. 1. " NUM2 ,Contains the number of the DMA request or channel that triggers the pulse on the cross-trigger event line number i ."
        textline "           "
        bitfld.long 0x00 22. " CNF2 ,Configuration of the SDMA event line number i that is connected to the cross-trigger." "0,1"
        textline "           "
        hexmask.long.byte 0x00 24.--30. 1. " NUM3 ,Contains the number of the DMA request or channel that triggers the pulse on the cross-trigger event line number i ."
        textline "           "
        bitfld.long 0x00 30. " CNF3 ,Configuration of the SDMA event line number i that is connected to the cross-trigger." "0,1"
width 12.
group.long 0x74++0x3
    line.long 0x00 "XTRIG_CONF2,Cross-Trigger Events Configuration Register 2"
        hexmask.long.byte 0x00 0.--6. 1. " NUM4 ,Contains the number of the DMA request or channel that triggers the pulse on the cross-trigger event line number i ."
        textline "           "
        bitfld.long 0x00 6. " CNF4 ,Configuration of the SDMA event line number i that is connected to the cross-trigger." "0,1"
        textline "           "
        hexmask.long.byte 0x00 8.--14. 1. " NUM5 ,Contains the number of the DMA request or channel that triggers the pulse on the cross-trigger event line number i ."
        textline "           "
        bitfld.long 0x00 14. " CNF5 ,Configuration of the SDMA event line number i that is connected to the cross-trigger." "0,1"
        textline "           "
        hexmask.long.byte 0x00 16.--22. 1. " NUM6 ,Contains the number of the DMA request or channel that triggers the pulse on the cross-trigger event line number i ."
        textline "           "
        bitfld.long 0x00 22. " CNF6 ,Configuration of the SDMA event line number i that is connected to the cross-trigger." "0,1"
        textline "           "
        hexmask.long.byte 0x00 24.--30. 1. " NUM7 ,Contains the number of the DMA request or channel that triggers the pulse on the cross-trigger event line number i ."
        textline "           "
        bitfld.long 0x00 30. " CNF7 ,Configuration of the SDMA event line number i that is connected to the cross-trigger." "0,1"
width 13.
group.long 0x100++0x3
    line.long 0x00 "SDMA_CHNPRI0,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 13.
group.long 0x104++0x3
    line.long 0x00 "SDMA_CHNPRI1,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 13.
group.long 0x108++0x3
    line.long 0x00 "SDMA_CHNPRI2,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 13.
group.long 0x10c++0x3
    line.long 0x00 "SDMA_CHNPRI3,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 13.
group.long 0x110++0x3
    line.long 0x00 "SDMA_CHNPRI4,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 13.
group.long 0x114++0x3
    line.long 0x00 "SDMA_CHNPRI5,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 13.
group.long 0x118++0x3
    line.long 0x00 "SDMA_CHNPRI6,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 13.
group.long 0x11c++0x3
    line.long 0x00 "SDMA_CHNPRI7,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 13.
group.long 0x120++0x3
    line.long 0x00 "SDMA_CHNPRI8,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 13.
group.long 0x124++0x3
    line.long 0x00 "SDMA_CHNPRI9,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x128++0x3
    line.long 0x00 "SDMA_CHNPRI10,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x12c++0x3
    line.long 0x00 "SDMA_CHNPRI11,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x130++0x3
    line.long 0x00 "SDMA_CHNPRI12,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x134++0x3
    line.long 0x00 "SDMA_CHNPRI13,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x138++0x3
    line.long 0x00 "SDMA_CHNPRI14,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x13c++0x3
    line.long 0x00 "SDMA_CHNPRI15,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x140++0x3
    line.long 0x00 "SDMA_CHNPRI16,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x144++0x3
    line.long 0x00 "SDMA_CHNPRI17,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x148++0x3
    line.long 0x00 "SDMA_CHNPRI18,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x14c++0x3
    line.long 0x00 "SDMA_CHNPRI19,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x150++0x3
    line.long 0x00 "SDMA_CHNPRI20,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x154++0x3
    line.long 0x00 "SDMA_CHNPRI21,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x158++0x3
    line.long 0x00 "SDMA_CHNPRI22,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x15c++0x3
    line.long 0x00 "SDMA_CHNPRI23,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x160++0x3
    line.long 0x00 "SDMA_CHNPRI24,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x164++0x3
    line.long 0x00 "SDMA_CHNPRI25,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x168++0x3
    line.long 0x00 "SDMA_CHNPRI26,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x16c++0x3
    line.long 0x00 "SDMA_CHNPRI27,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x170++0x3
    line.long 0x00 "SDMA_CHNPRI28,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x174++0x3
    line.long 0x00 "SDMA_CHNPRI29,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x178++0x3
    line.long 0x00 "SDMA_CHNPRI30,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 14.
group.long 0x17c++0x3
    line.long 0x00 "SDMA_CHNPRI31,Channel Priority Registers"
        hexmask.long.byte 0x00 0.--3. 1. " CHNPRIN ,This contains the priority of channel number n ."
width 9.
group.long 0x200++0x3
    line.long 0x00 "CHNENBL0,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 9.
group.long 0x204++0x3
    line.long 0x00 "CHNENBL1,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 9.
group.long 0x208++0x3
    line.long 0x00 "CHNENBL2,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 9.
group.long 0x20c++0x3
    line.long 0x00 "CHNENBL3,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 9.
group.long 0x210++0x3
    line.long 0x00 "CHNENBL4,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 9.
group.long 0x214++0x3
    line.long 0x00 "CHNENBL5,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 9.
group.long 0x218++0x3
    line.long 0x00 "CHNENBL6,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 9.
group.long 0x21c++0x3
    line.long 0x00 "CHNENBL7,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 9.
group.long 0x220++0x3
    line.long 0x00 "CHNENBL8,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 9.
group.long 0x224++0x3
    line.long 0x00 "CHNENBL9,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x228++0x3
    line.long 0x00 "CHNENBL10,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x22c++0x3
    line.long 0x00 "CHNENBL11,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x230++0x3
    line.long 0x00 "CHNENBL12,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x234++0x3
    line.long 0x00 "CHNENBL13,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x238++0x3
    line.long 0x00 "CHNENBL14,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x23c++0x3
    line.long 0x00 "CHNENBL15,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x240++0x3
    line.long 0x00 "CHNENBL16,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x244++0x3
    line.long 0x00 "CHNENBL17,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x248++0x3
    line.long 0x00 "CHNENBL18,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x24c++0x3
    line.long 0x00 "CHNENBL19,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x250++0x3
    line.long 0x00 "CHNENBL20,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x254++0x3
    line.long 0x00 "CHNENBL21,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x258++0x3
    line.long 0x00 "CHNENBL22,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x25c++0x3
    line.long 0x00 "CHNENBL23,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x260++0x3
    line.long 0x00 "CHNENBL24,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x264++0x3
    line.long 0x00 "CHNENBL25,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x268++0x3
    line.long 0x00 "CHNENBL26,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x26c++0x3
    line.long 0x00 "CHNENBL27,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x270++0x3
    line.long 0x00 "CHNENBL28,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x274++0x3
    line.long 0x00 "CHNENBL29,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x278++0x3
    line.long 0x00 "CHNENBL30,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x27c++0x3
    line.long 0x00 "CHNENBL31,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x280++0x3
    line.long 0x00 "CHNENBL32,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x284++0x3
    line.long 0x00 "CHNENBL33,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x288++0x3
    line.long 0x00 "CHNENBL34,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x28c++0x3
    line.long 0x00 "CHNENBL35,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x290++0x3
    line.long 0x00 "CHNENBL36,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x294++0x3
    line.long 0x00 "CHNENBL37,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x298++0x3
    line.long 0x00 "CHNENBL38,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x29c++0x3
    line.long 0x00 "CHNENBL39,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x2a0++0x3
    line.long 0x00 "CHNENBL40,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x2a4++0x3
    line.long 0x00 "CHNENBL41,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x2a8++0x3
    line.long 0x00 "CHNENBL42,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x2ac++0x3
    line.long 0x00 "CHNENBL43,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x2b0++0x3
    line.long 0x00 "CHNENBL44,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x2b4++0x3
    line.long 0x00 "CHNENBL45,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x2b8++0x3
    line.long 0x00 "CHNENBL46,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."
width 10.
group.long 0x2bc++0x3
    line.long 0x00 "CHNENBL47,Channel Enable RAM"
        hexmask.long.long 0x00 0.--32. 1. " ENBLN ,This 32-bit value selects the channels that are triggered by the DMA request number n ."


tree.end



;--------------------------------------------------------------------------------
; SDMABP
;--------------------------------------------------------------------------------
tree "SDMABP"
    base ad:0x020ec000

width 7.
group.long 0x0++0x3
    line.long 0x00 "DC0PTR,Channel 0 Pointer"
        hexmask.long.long 0x00 0.--32. 1. " DC0PTR ,Channel 0 Pointer contains the 32-bit address, in BP memory, of the array of channel control blocks starting with the one for channel 0 (the control channel)."
width 5.
group.long 0x4++0x3
    line.long 0x00 "INTR,Channel Interrupts"
        hexmask.long.long 0x00 0.--32. 1. " DI ,The BP Interrupts register contains the 32 DI[i] bits."
width 10.
group.long 0x8++0x3
    line.long 0x00 "STOP_STAT,Channel Stop/Channel Status"
        hexmask.long.long 0x00 0.--32. 1. " DE ,This 32-bit register gives access to the BP (DSP) Enable bits, DE."
width 7.
rgroup.long 0xc++0x3
    line.long 0x00 "DSTART,Channel Start"
        hexmask.long.long 0x00 0.--32. 1. " DSTART_DE ,The DSTART_DE registers are 32 bits wide with one bit for every channel."
width 7.
rgroup.long 0x28++0x3
    line.long 0x00 "EVTERR,DMA Request Error Register"
        hexmask.long.long 0x00 0.--32. 1. " CHNERR ,This register is used by the SDMA to warn the BP when an incoming DMA request was detected; it then triggers a channel that is already pending or being serviced, which may mean there is an overflow of data for that channel."
width 9.
group.long 0x2c++0x3
    line.long 0x00 "INTRMASK,Channel DSP Interrupt Mask"
        hexmask.long.long 0x00 0.--32. 1. " DIMASK ,The Interrupt Mask Register contains 32 interrupt generation mask bits."
width 10.
rgroup.long 0x34++0x3
    line.long 0x00 "EVTERRDBG,DMA Request Error Register"
        hexmask.long.long 0x00 0.--32. 1. " CHNERR ,This register is the same as EVTERR except reading it does not clear its contents."


tree.end



;--------------------------------------------------------------------------------
; SDMACORE
;--------------------------------------------------------------------------------
tree "SDMACORE"
    base ad:0x020ec000

width 7.
rgroup.long 0x0++0x3
    line.long 0x00 "MC0PTR,ARM platform Channel 0 Pointer"
        hexmask.long.long 0x00 0.--32. 1. " MC0PTR ,Contains the address-in the ARM platform memory space-of the initial SDMA context and scripts that are loaded by the SDMA boot script running on channel 0."
width 6.
rgroup.long 0x2++0x3
    line.long 0x00 "CCPTR,Current Channel Pointer"
        hexmask.long.word 0x00 0.--16. 1. " CCPTR ,Contains the start address of the context data for the current channel: Its value is CONTEXT_BASE + 24* CCR or CONTEXT_BASE + 32* CCR where CONTEXT_BASE = 0x0800."
width 4.
rgroup.long 0x3++0x3
    line.long 0x00 "CCR,Current Channel Register"
        hexmask.long.byte 0x00 0.--5. 1. " CCR ,Contains the number of the current running channel whose context is installed."
width 4.
rgroup.long 0x4++0x3
    line.long 0x00 "NCR,Highest Pending Channel Register"
        hexmask.long.byte 0x00 0.--5. 1. " NCR ,Contains the number of the pending channel that the scheduler has selected to run next."
width 7.
rgroup.long 0x5++0x3
    line.long 0x00 "EVENTS,External DMA Requests Mirror"
        hexmask.long.long 0x00 0.--32. 1. " EVENTS ,Reflects the status of the SDMA's external DMA requests."
width 6.
rgroup.long 0x6++0x3
    line.long 0x00 "CCPRI,Current Channel Priority"
        hexmask.long.byte 0x00 0.--3. 1. " CCPRI ,Contains the 3-bit priority of the channel whose context is installed."
width 6.
rgroup.long 0x7++0x3
    line.long 0x00 "NCPRI,Next Channel Priority"
        hexmask.long.byte 0x00 0.--3. 1. " NCPRI ,Contains the 3-bit priority of the channel the scheduler has selected to run next."
width 7.
group.long 0x9++0x3
    line.long 0x00 "ECOUNT,OnCE Event Cell Counter"
        hexmask.long.word 0x00 0.--16. 1. " ECOUNT ,The event cell counter contains the number of times minus one that an event detection must occur before generating a debug request."
width 5.
group.long 0xa++0x3
    line.long 0x00 "ECTL,OnCE Event Cell Control Register"
        hexmask.long.byte 0x00 0.--2. 1. " ATS ,The access type select bits define the memory access type required on the SDMA memory bus."
        textline "    "
        hexmask.long.byte 0x00 2.--4. 1. " AATC ,The Address A Trigger Condition (AATC) controls the operations performed by address comparator A."
        textline "    "
        hexmask.long.byte 0x00 4.--6. 1. " ABTC ,The Address B Trigger Condition (ABTC) controls the operations performed by address comparator B."
        textline "    "
        hexmask.long.byte 0x00 6.--8. 1. " ATC ,The address trigger condition bits select how the two address conditions (addressA and addressB) are combined to define the global address matching condition."
        textline "    "
        hexmask.long.byte 0x00 8.--10. 1. " DTC ,The data trigger condition bits define when data is considered matching after comparison with the data register of the event detection unit."
        textline "    "
        hexmask.long.byte 0x00 10.--12. 1. " ECTC ,The event cell trigger condition bits select the combination of address and data matching conditions that generate the final address/data condition."
        textline "    "
        bitfld.long 0x00 12. " CNT ,Event Counter Enable." "0,1"
        textline "    "
        bitfld.long 0x00 13. " EN ,Event Cell Enable." "0,1"
width 4.
group.long 0xb++0x3
    line.long 0x00 "EAA,OnCE Event Address Register A"
        hexmask.long.word 0x00 0.--16. 1. " EAA ,Event Cell Address Register A computes an address A condition."
width 4.
group.long 0xc++0x3
    line.long 0x00 "EAB,OnCE Event Cell Address Register B"
        hexmask.long.word 0x00 0.--16. 1. " EAB ,Event Cell Address Register B computes an address B condition."
width 4.
group.long 0xd++0x3
    line.long 0x00 "EAM,OnCE Event Cell Address Mask"
        hexmask.long.word 0x00 0.--16. 1. " EAM ,The Event Cell Address Mask contains a user-defined address mask value."
width 3.
group.long 0xe++0x3
    line.long 0x00 "ED,OnCE Event Cell Data Register"
        hexmask.long.long 0x00 0.--32. 1. " ED ,The event cell data register contains a user defined data value."
width 4.
group.long 0xf++0x3
    line.long 0x00 "EDM,OnCE Event Cell Data Mask"
        hexmask.long.long 0x00 0.--32. 1. " EDM ,The event cell data mask register contains the user-defined data mask value."
width 4.
group.long 0x18++0x3
    line.long 0x00 "RTB,OnCE Real-Time Buffer"
        hexmask.long.long 0x00 0.--32. 1. " RTB ,The Real Time Buffer register stores and retrieves run time information without putting the SDMA in debug mode."
width 3.
rgroup.long 0x19++0x3
    line.long 0x00 "TB,OnCE Trace Buffer"
        hexmask.long.word 0x00 0.--14. 1. " CHFADDR ,The change of flow address is the address where the change of flow is taken when executing a change of flow instruction."
        textline "  "
        hexmask.long.word 0x00 14.--28. 1. " TADDR ,The target address is the address taken after the execution of the change of flow instruction."
        textline "  "
        bitfld.long 0x00 28. " TBF ,The Trace Buffer Flag is set when the buffer contains the addresses of a valid change of flow." "0,1"
width 6.
rgroup.long 0x1a++0x3
    line.long 0x00 "OSTAT,OnCE Status"
        hexmask.long.byte 0x00 0.--3. 1. " ECDR ,Event Cell Debug Request."
        textline "     "
        bitfld.long 0x00 7. " MST ,This flag is raised when the OnCE is controlled from the ARM platform peripheral interface." "0,1"
        textline "     "
        bitfld.long 0x00 8. " SWB ,This flag is raised when the SDMA has entered debug mode after a software breakpoint." "0,1"
        textline "     "
        bitfld.long 0x00 9. " ODR ,This flag is raised when the SDMA has entered debug mode after a OnCE debug request." "0,1"
        textline "     "
        bitfld.long 0x00 10. " EDR ,This flag is raised when the SDMA has entered debug mode after an external debug request." "0,1"
        textline "     "
        bitfld.long 0x00 11. " RCV ,After each write access to the real time buffer (RTB), the RCV bit is set." "0,1"
        textline "     "
        hexmask.long.byte 0x00 12.--16. 1. " PST ,The Processor Status bits reflect the state of the SDMA RISC engine."
width 10.
rgroup.long 0x1c++0x3
    line.long 0x00 "MCHN0ADDR,Channel 0 Boot Address"
        hexmask.long.word 0x00 0.--14. 1. " CHN0ADDR ,Contains the address of the channel 0 routine programmed by the ARM platform; it is loaded into a general register at the very start of the boot and the SDMA jumps to the address it contains."
        textline "         "
        bitfld.long 0x00 14. " SMSZ ,The bit 14 (Scratch Memory Size) determines if scratch memory must be available after every channel context." "0,1"
width 11.
rgroup.long 0x1d++0x3
    line.long 0x00 "ENDIANNESS,ENDIAN Status Register"
        bitfld.long 0x00 0. " APEND ,APEND indicates the endian mode of the Peripheral and Burst DMA interfaces." "0,1"
width 10.
rgroup.long 0x1e++0x3
    line.long 0x00 "SDMA_LOCK,Lock Status Register"
        bitfld.long 0x00 0. " LOCK ,The LOCK bit reports the value of the LOCK bit in the SDMA_LOCK status register." "0,1"
width 8.
rgroup.long 0x1f++0x3
    line.long 0x00 "EVENTS2,External DMA Requests Mirror #2"
        hexmask.long.word 0x00 0.--16. 1. " EVENTS ,Reflects the status of the SDMA's external DMA requests."


tree.end



;--------------------------------------------------------------------------------
; SJC
;--------------------------------------------------------------------------------
tree "SJC"
    base ad:0x00000000

width 7.
rgroup.long 0x0++0x3
    line.long 0x00 "GPUSR1,General Purpose Unsecured Status Register 1"
        bitfld.long 0x00 0. " A_DBG ,ARM core debug status bit Bit 0 is the ARM core DBGACK (debug acknowledge) DBGACK can be overwritten in the ARM core DCR to force a particular DBGACK value." "0,1"
        textline "      "
        bitfld.long 0x00 1. " A_WFI ,ARM core wait-for interrupt bit Bit 1 is the ARM core standbywfi (stand by wait-for interrupt)." "0,1"
        textline "      "
        hexmask.long.byte 0x00 2.--5. 1. " S_STAT ,3 LSBits of SDMA core statusH."
        textline "      "
        bitfld.long 0x00 8. " PLL_LOCK ,PLL_LOCK A Combined PLL-Lock flag indicator, for all the PLL's." "0,1"
width 7.
rgroup.long 0x1++0x3
    line.long 0x00 "GPUSR2,General Purpose Unsecured Status Register 2"
        hexmask.long.byte 0x00 0.--4. 1. " STBYWFI ,STBYWFI[3:0] These bits provide status of ""Standby Wait-For-Interrupt"" state of all ARM cores."
        textline "      "
        hexmask.long.byte 0x00 4.--8. 1. " S_STAT ,S_STAT[3:0] SDMA debug status bits: debug_core_state[3:0]"
        textline "      "
        hexmask.long.byte 0x00 8.--12. 1. " STBYWFE ,STBYWFE[3:0] Reflecting the ""Standby Wait For Event"" signals of all cores."
width 7.
rgroup.long 0x2++0x3
    line.long 0x00 "GPUSR3,General Purpose Unsecured Status Register 3"
        bitfld.long 0x00 0. " IPG_WAIT ,IPG_WAIT CCM's ""ipg_wait"" signal indication" "0,1"
        textline "      "
        bitfld.long 0x00 1. " IPG_STOP ,IPG_STOP CCM's ""ipg_stop"" signal indication" "0,1"
        textline "      "
        bitfld.long 0x00 2. " SYS_WAIT ,System In wait Indication on System in wait mode (from CCM)." "0,1"
width 6.
rgroup.long 0x3++0x3
    line.long 0x00 "GPSSR,General Purpose Secured Status Register"
        hexmask.long.long 0x00 0.--32. 1. " GPSSR ,General Purpose Secured Status Register Register is used for testing and debug."
width 4.
group.long 0x4++0x3
    line.long 0x00 "DCR,Debug Control Register"
        bitfld.long 0x00 0. " DE_TO_ARM ,ARM platform debug request input propagation This bit controls the propagation of debug request to ARM platform (""dbgreq""), when the JTAG state machine is put in ""ENTER_DEBUG"" IR instruction." "0,1"
        textline "   "
        bitfld.long 0x00 1. " DE_TO_SDMA ,SDMA debug request input propagation This bit controls the propagation of debug request to SDMA, when the JTAG state machine is put in ""ENTER_DEBUG"" IR instruction.." "0,1"
        textline "   "
        bitfld.long 0x00 3. " DEBUG_OBS ,Debug observability This bit controls the propagation of the ""system debug"" input to SJC For i.MX 6x, the SJC's ""system_debug"" input is tied to logic HIGH value, therefore, set of ""debug_obs"" bit, will result in unconditional assertion of DE_B pad." "0,1"
        textline "   "
        bitfld.long 0x00 5. " DIRECT_SDMA_REQ_EN ,Debug enable of the sdma debug request This bit controls the propagation of debug request DE_B to the sdma." "0,1"
        textline "   "
        bitfld.long 0x00 6. " DIRECT_ARM_REQ_EN ,Pass Debug Enable event from DE_B pin to ARM platform debug request signal(s)." "0,1"
width 4.
rgroup.long 0x5++0x3
    line.long 0x00 "SSR,Security Status Register"
        bitfld.long 0x00 0. " KTF ,Kill Trace Enable fuse value" "0,1"
        textline "   "
        bitfld.long 0x00 1. " KTA ,Kill Trace is active" "0,1"
        textline "   "
        bitfld.long 0x00 2. " SWF ,Software JTAG enable fuse Status of the no SW disable JTAG fuse" "0,1"
        textline "   "
        bitfld.long 0x00 3. " SWE ,SW enable SW JTAG enable status" "0,1"
        textline "   "
        bitfld.long 0x00 4. " EBF ,External Boot fuse Status of the external boot disable fuse" "0,1"
        textline "   "
        bitfld.long 0x00 5. " EBG ,External boot granted External boot enabled, requested and granted" "0,1"
        textline "   "
        bitfld.long 0x00 8. " FT ,Fuse type Fuse type bit - e-fuse or laser fuse" "0,1"
        textline "   "
        hexmask.long.byte 0x00 9.--11. 1. " SJM ,SJC Secure mode Secure JTAG mode, as set by external fuses."
        textline "   "
        hexmask.long.byte 0x00 11.--13. 1. " RSSTAT ,Response status Response status bits"
        textline "   "
        bitfld.long 0x00 14. " BOOTIND ,Boot Indication Inverted Internal Boot indication, i.e inverse of SRC: ""src_int_boot"" signal" "0,1"
width 6.
group.long 0x7++0x3
    line.long 0x00 "GPCCR,General Purpose Clocks Control Register"
        bitfld.long 0x00 0. " SCLKR ,SDMA Clock ON Register - This bit forces the clock on of the SDMA" "0,1"
        textline "     "
        bitfld.long 0x00 1. " ACLKOFFDIS ,Disable/prevent ARM platform clock/power shutdown" "0,1"


tree.end



;--------------------------------------------------------------------------------
; SNVS
;--------------------------------------------------------------------------------
tree "SNVS"
    base ad:0x020cc000

width 5.
group.long 0x0++0x3
    line.long 0x00 "HPLR,SNVS _HP Lock Register"
        bitfld.long 0x00 0. " ZMK_WSL ,Zeroizable Master Key Write Soft Lock When set, prevents any writes (software and hardware) to the ZMK registers and MASTER_KEY_SEL, ZMK_HWP, ZMK_VAL, and ZMK_ECC_EN fields of the LPMKCR." "0,1"
        textline "    "
        bitfld.long 0x00 1. " ZMK_RSL ,Zeroizable Master Key Read Soft Lock When set, prevents any software reads to the ZMK Registers and ZMK_ECC_VALUE field of the LPMKCR." "0,1"
        textline "    "
        bitfld.long 0x00 2. " SRTC_SL ,Secure Real Time Counter Soft Lock When set, prevents any writes to the SRTC Registers, SRTC_ENV, and SRTC_INV_EN bits." "0,1"
        textline "    "
        bitfld.long 0x00 3. " LPCALB_SL ,LP Calibration Soft Lock When set, prevents any writes to the LP Calibration Value (LPCALB_VAL) and LP Calibration Enable (LPCALB_EN)." "0,1"
        textline "    "
        bitfld.long 0x00 4. " MC_SL ,Monotonic Counter Soft Lock When set, prevents any writes (increments) to the MC Registers and MC_ENV bit." "0,1"
        textline "    "
        bitfld.long 0x00 5. " GPR_SL ,General Purpose Register Soft Lock When set, prevents any writes to the GPR." "0,1"
        textline "    "
        bitfld.long 0x00 6. " LPSVCR_SL ,LP Security Violation Control Register Soft Lock When set, prevents any writes to the LPSVCR." "0,1"
        textline "    "
        bitfld.long 0x00 7. " LPTGFCR_SL ,LP Tamper Glitch Filter Configuration Register Soft Lock When set, prevents any writes to the LPTGFCR." "0,1"
        textline "    "
        bitfld.long 0x00 8. " LPTDCR_SL ,LP Tamper Detectors Configuration Register Soft Lock When set, prevents any writes to the LPTDCR." "0,1"
        textline "    "
        bitfld.long 0x00 9. " MKS_SL ,Master Key Select Soft Lock When set, prevents any writes to the MASTER_KEY_SEL field of the LPMKCR." "0,1"
        textline "    "
        bitfld.long 0x00 16. " HPSVCR_L ,HP Security Violation Control Register Lock When set, prevents any writes to the HPSVCR." "0,1"
        textline "    "
        bitfld.long 0x00 17. " HPSICR_L ,HP Security Interrupt Control Register Lock When set, prevents any writes to the HPSICR." "0,1"
        textline "    "
        bitfld.long 0x00 18. " HAC_L ,High Assurance Configuration Lock When set, prevents any writes to HPHACIVR, HPHACR, and HAC_EN bit of HPCOMR." "0,1"
width 7.
group.long 0x4++0x3
    line.long 0x00 "HPCOMR,SNVS _HP Command Register"
        bitfld.long 0x00 0. " SSM_ST ,SSM State Transition Transition state of the system security monitor." "0,1"
        textline "      "
        bitfld.long 0x00 1. " SSM_ST_DIS ,SSM Secure to Trusted State Transition Disable When set, disables the SSM transition from secure to trusted state." "0,1"
        textline "      "
        bitfld.long 0x00 2. " SSM_SFNS_DIS ,SSM Soft Fail to Non-Secure State Transition Disable When set, it disables the SSM transition from soft fail to non-secure state." "0,1"
        textline "      "
        bitfld.long 0x00 4. " LP_SWR ,LP Software Reset When set, it resets the SNVS _LP section." "0,1"
        textline "      "
        bitfld.long 0x00 5. " LP_SWR_DIS ,LP Software Reset Disable When set, disables the LP software reset." "0,1"
        textline "      "
        bitfld.long 0x00 8. " SW_SV ,Software Security Violation When set, the system security monitor treats this bit as a non-fatal security violation." "0,1"
        textline "      "
        bitfld.long 0x00 9. " SW_FSV ,Software Fatal Security Violation When set, the system security monitor treats this bit as a fatal security violation." "0,1"
        textline "      "
        bitfld.long 0x00 10. " SW_LPSV ,LP Software Security Violation When set, SNVS _LP treats this bit as a security violation." "0,1"
        textline "      "
        bitfld.long 0x00 12. " PROG_ZMK ,Program Zeroizable Master Key This bit activates ZMK hardware programming mechanism." "0,1"
        textline "      "
        bitfld.long 0x00 13. " MKS_EN ,Master Key Select Enable When not set, the one time programmable (OTP) master key is selected by default." "0,1"
        textline "      "
        bitfld.long 0x00 16. " HAC_EN ,High Assurance Configuration Enable This bit controls the SSM transition from the soft fail to the hard fail state." "0,1"
        textline "      "
        bitfld.long 0x00 17. " HAC_LOAD ,High Assurance Counter Load When set, it loads the High Assurance Counter Register with the value of the High Assurance Counter Load Register." "0,1"
        textline "      "
        bitfld.long 0x00 18. " HAC_CLEAR ,High Assurance Counter Clear When set, it clears the High Assurance Counter Register." "0,1"
        textline "      "
        bitfld.long 0x00 19. " HAC_STOP ,High Assurance Counter Stop This bit can be set only when SSM is in soft fail state." "0,1"
        textline "      "
        bitfld.long 0x00 31. " NPSWA_EN ,Non-Privileged Software Access Enable When set, allows non-privileged software to access all SNVS registers, including those that are privileged software read/write access only." "0,1"
width 5.
group.long 0x8++0x3
    line.long 0x00 "HPCR,SNVS_HP Control Register"
        bitfld.long 0x00 0. " RTC_EN ,HP Real Time Counter Enable" "0,1"
        textline "    "
        bitfld.long 0x00 1. " HPTA_EN ,HP Time Alarm Enable When set, the time alarm interrupt is generated if the value in the HP Time Alarm Registers is equal to the value of the HP Real Time Counter." "0,1"
        textline "    "
        bitfld.long 0x00 3. " PI_EN ,HP Periodic Interrupt Enable The periodic interrupt can be generated only if the HP Real Time Counter is enabled." "0,1"
        textline "    "
        hexmask.long.byte 0x00 4.--8. 1. " PI_FREQ ,Periodic Interrupt Frequency Defines frequency of the periodic interrupt."
        textline "    "
        bitfld.long 0x00 8. " HPCALB_EN ,HP Real Time Counter Calibration Enabled Indicates that the time calibration mechanism is enabled." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--15. 1. " HPCALB_VAL ,HP Calibration Value Defines signed calibration value for the HP Real Time Counter."
        textline "    "
        bitfld.long 0x00 16. " HP_TS ,HP Time Synchronize When set, this updates the HP Time Counter with the LP Time Counter value." "0,1"
width 7.
group.long 0xc++0x3
    line.long 0x00 "HPSICR,SNVS _HP Security Interrupt Control Register"
        bitfld.long 0x00 0. " SVI_EN0 ,Security Violation Interrupt 0 Enable This bit enables generation of the security interrupt to the host processor upon security violation detection on input port 0." "0,1"
        textline "      "
        bitfld.long 0x00 1. " SVI_EN1 ,Security Violation Interrupt 1 Enable This bit enables generation of the security interrupt to the host processor upon security violation detection on input port 1." "0,1"
        textline "      "
        bitfld.long 0x00 2. " SVI_EN2 ,Security Violation Interrupt 2 Enable This bit enables generation of the security interrupt to the host processor upon security violation detection on input port 2." "0,1"
        textline "      "
        bitfld.long 0x00 3. " SVI_EN3 ,Security Violation Interrupt 3 Enable This bit enables generation of the security interrupt to the host processor upon security violation detection on input port 3." "0,1"
        textline "      "
        bitfld.long 0x00 4. " SVI_EN4 ,Security Violation Interrupt 4 Enable This bit enables generation of the security interrupt to the host processor upon security violation detection on input port 4." "0,1"
        textline "      "
        bitfld.long 0x00 5. " SVI_EN5 ,Security Violation Interrupt 5 Enable This bit enables generation of the security interrupt to the host processor upon security violation detection on input port 5." "0,1"
        textline "      "
        bitfld.long 0x00 31. " LPSVI_EN ,LP Security Violation Interrupt Enable This bit enables generating of the security interrupt to the host processor upon security violation signal from the LP section." "0,1"
width 7.
group.long 0x10++0x3
    line.long 0x00 "HPSVCR,SNVS _HP Security Violation Control Register"
        bitfld.long 0x00 0. " SV_CFG0 ,Security Violation Input 0 Configuration This field configures the security violation input 0." "0,1"
        textline "      "
        bitfld.long 0x00 1. " SV_CFG1 ,Security Violation Input 1 Configuration This field configures the Security Violation Input 1." "0,1"
        textline "      "
        bitfld.long 0x00 2. " SV_CFG2 ,Security Violation Input 2 Configuration This field configures the security violation input 2." "0,1"
        textline "      "
        bitfld.long 0x00 3. " SV_CFG3 ,Security Violation Input 3 Configuration This field configures the security violation input 3." "0,1"
        textline "      "
        bitfld.long 0x00 4. " SV_CFG4 ,Security Violation Input 4 Configuration This field configures the security violation Input 4." "0,1"
        textline "      "
        hexmask.long.byte 0x00 5.--7. 1. " SV_CFG5 ,Security Violation Input 5 Configuration This field configures the Security Violation Input 5."
        textline "      "
        hexmask.long.byte 0x00 30.--32. 1. " LPSV_CFG ,LP Security Violation Configuration This field configures the LP security violation source."
width 5.
group.long 0x14++0x3
    line.long 0x00 "HPSR,SNVS _HP Status Register"
        bitfld.long 0x00 0. " HPTA ,HP Time Alarm Indicates that the HP Time Alarm has occurred since this bit was last cleared." "0,1"
        textline "    "
        bitfld.long 0x00 1. " PI ,Periodic Interrupt Indicates that periodic interrupt has occurred since this bit was last cleared." "0,1"
        textline "    "
        bitfld.long 0x00 4. " LPDIS ,Low Power Disable If 1, the SNVS low power section has been disabled by means of an input signal to the SNVS ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 8.--12. 1. " SSM_ST ,System Security Monitor State This field contains the encoded state of the SSM's state machine."
        textline "    "
        hexmask.long.byte 0x00 12.--15. 1. " SYS_SECURITY_CFG ,This field reflects the value of the sys_security_cfg input signal, which is defined as follows:"
        textline "    "
        bitfld.long 0x00 15. " SYS_SECURE_BOOT ,This bit reflects the value of the sys_secure_boot input signal to SNVS ." "0,1"
        textline "    "
        hexmask.long.word 0x00 16.--25. 1. " OTPMK_SYNDROME ,One Time Programmable Master Key Syndrome Value The eight lower bits of this value indicate error location in case of a single-bit error."
        textline "    "
        bitfld.long 0x00 27. " OTPMK_ZERO ,One Time Programmable Master Key is Equal to Zero." "0,1"
        textline "    "
        bitfld.long 0x00 31. " ZMK_ZERO ,Zeroizable Master Key is Equal to Zero." "0,1"
width 7.
group.long 0x18++0x3
    line.long 0x00 "HPSVSR,SNVS _HP Security Violation Status Register"
        bitfld.long 0x00 0. " SEC_VIO0 ,Security violation on input 0 is detected." "0,1"
        textline "      "
        bitfld.long 0x00 1. " SEC_VIO1 ,Security violation on input 1 is detected." "0,1"
        textline "      "
        bitfld.long 0x00 2. " SEC_VIO2 ,Security violation on input 2 is detected." "0,1"
        textline "      "
        bitfld.long 0x00 3. " SEC_VIO3 ,Security violation on input 3 is detected." "0,1"
        textline "      "
        bitfld.long 0x00 4. " SEC_VIO4 ,Security violation on input 4 is detected." "0,1"
        textline "      "
        bitfld.long 0x00 5. " SEC_VIO5 ,Security volation on input 5 is detected." "0,1"
        textline "      "
        hexmask.long.word 0x00 16.--25. 1. " ZMK_SYNDROME ,Zeroizable Master Key Syndrome Value The ZMK syndrome indicates error location and parity similar to the OTPMK syndrome ."
        textline "      "
        bitfld.long 0x00 27. " ZMK_ECC_FAIL ,Zeroizable Master Key Error Correcting Code Check Failure When set, this bit triggers a bad key violation to the SSM and a security violation to the SNVS _LP section, which clears security sensitive data." "0,1"
width 9.
group.long 0x1c++0x3
    line.long 0x00 "HPHACIVR,SNVS _HP High Assurance Counter IV Register"
        hexmask.long.long 0x00 0.--32. 1. " HAC_COUNTER_IV ,High Assurance Counter Initial Value This register is used to set the starting count value to the high assurance counter."
width 7.
group.long 0x20++0x3
    line.long 0x00 "HPHACR,SNVS _HP High Assurance Counter Register"
        hexmask.long.long 0x00 0.--32. 1. " HAC_COUNTER ,High Assurance Counter When the HAC_EN bit is set and the SSM is in the soft fail state, this counter starts to count down with the system clock."
width 8.
group.long 0x24++0x3
    line.long 0x00 "HPRTCMR,SNVS_HP Real Time Counter MSB Register"
        hexmask.long.word 0x00 0.--15. 1. " RTC ,HP Real Time Counter Most significant 15 bits."
width 8.
group.long 0x28++0x3
    line.long 0x00 "HPRTCLR,SNVS_HP Real Time Counter LSB Register"
        hexmask.long.long 0x00 0.--32. 1. " RTC ,HP Real Time Counter Least significant 32 bits."
width 7.
group.long 0x2c++0x3
    line.long 0x00 "HPTAMR,SNVS_HP Time Alarm MSB Register"
        hexmask.long.word 0x00 0.--15. 1. " HPTA ,HP Time Alarm Most significant 15 bits."
width 7.
group.long 0x30++0x3
    line.long 0x00 "HPTALR,SNVS_HP Time Alarm LSB Register"
        hexmask.long.long 0x00 0.--32. 1. " HPTA ,HP Time Alarm Least significant bits."
width 5.
group.long 0x34++0x3
    line.long 0x00 "LPLR,SNVS _LP Lock Register"
        bitfld.long 0x00 0. " ZMK_WHL ,Zeroizable Master Key Write Hard Lock When set, prevents any writes (software and hardware) to the ZMK registers and ZMK_HWP, ZMK_VAL, and ZMK_ECC_EN fields of the LPMKCR." "0,1"
        textline "    "
        bitfld.long 0x00 1. " ZMK_RHL ,Zeroizable Master Key Read Hard Lock When set, prevents any software reads to the ZMK registers and ZMK_ECC_VALUE field of the LPMKCR." "0,1"
        textline "    "
        bitfld.long 0x00 2. " SRTC_HL ,Secure Real Time Counter Hard Lock When set, prevents any writes to the SRTC registers, SRTC_ENV, and SRTC_INV_EN bits." "0,1"
        textline "    "
        bitfld.long 0x00 3. " LPCALB_HL ,LP Calibration Hard Lock When set, prevents any writes to the LP Calibration Value (LPCALB_VAL) and LP Calibration Enable (LPCALB_EN)." "0,1"
        textline "    "
        bitfld.long 0x00 4. " MC_HL ,Monotonic Counter Hard Lock When set, prevents any writes (increments) to the MC Registers and MC_ENV bit." "0,1"
        textline "    "
        bitfld.long 0x00 5. " GPR_HL ,General Purpose Register Hard Lock When set, prevents any writes to the GPR." "0,1"
        textline "    "
        bitfld.long 0x00 6. " LPSVCR_HL ,LP Security Violation Control Register Hard Lock When set, prevents any writes to the LPSVCR." "0,1"
        textline "    "
        bitfld.long 0x00 7. " LPTGFCR_HL ,LP Tamper Glitch Filter Configuration Register Hard Lock When set, prevents any writes to the LPTGFCR." "0,1"
        textline "    "
        bitfld.long 0x00 8. " LPTDCR_HL ,LP Tamper Detectors Configuration Register Hard Lock When set, prevents any writes to the LPTDCR." "0,1"
        textline "    "
        bitfld.long 0x00 9. " MKS_HL ,Master Key Select Hard Lock When set, prevents any writes to the MASTER_KEY_SEL field of the LP Master Key Control Register." "0,1"
width 5.
group.long 0x38++0x3
    line.long 0x00 "LPCR,SNVS_LP Control Register"
        bitfld.long 0x00 0. " SRTC_ENV ,Secure Real Time Counter Enable and Valid When set, the SRTC becomes operational." "0,1"
        textline "    "
        bitfld.long 0x00 1. " LPTA_EN ,LP Time Alarm Enable When set, the SNVS functional interrupt is asserted if the LP Time Alarm Register is equal to the 32 MSBs of the secure real time counter." "0,1"
        textline "    "
        bitfld.long 0x00 2. " MC_ENV ,Monotonic Counter Enable and Valid When set, the MC can be incremented (by write transaction to the LPSMCMR or LPSMCLR)." "0,1"
        textline "    "
        bitfld.long 0x00 3. " LPWUI_EN ,LP Wake-Up Interrupt Enable This interrupt line should be connected to the external pin and is intended to inform the external chip about an SNVS _LP event (tamper event, MC rollover, SRTC rollover, or time alarm )." "0,1"
        textline "    "
        bitfld.long 0x00 4. " SRTC_INV_EN ,Secure Real Time Counter Invalidation Enable When set, the SRTC is invalidated (SRTC_ENV bit is cleared) in the case of security violation." "0,1"
        textline "    "
        bitfld.long 0x00 5. " DP_EN ,Dumb PMIC Enabled" "0,1"
        textline "    "
        bitfld.long 0x00 6. " TOP ,Turn of System Power Asserting this bit causes a signal to be sent to the Power Management IC to turn off the system power." "0,1"
        textline "    "
        bitfld.long 0x00 8. " LPCALB_EN ,LP Calibration Enable When set, enables the SRTC calibration mechanism." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--15. 1. " LPCALB_VAL ,LP Calibration Value Defines signed calibration value for SRTC."
width 7.
group.long 0x3c++0x3
    line.long 0x00 "LPMKCR,SNVS_LP Master Key Control Register"
        hexmask.long.byte 0x00 0.--2. 1. " MASTER_KEY_SEL ,Master Key Select These bits select the SNVS Master Key output when Master Key Select bits are enabled by MKS_EN bit in the HPCOMR ."
        textline "      "
        bitfld.long 0x00 2. " ZMK_HWP ,Zeroizable Master Key hardware Programming mode When set, only the hardware key programming mechanism can set the ZMK and software cannot read it." "0,1"
        textline "      "
        bitfld.long 0x00 3. " ZMK_VAL ,Zeroizable Master Key Valid When set, the ZMK value can be selected by the master key control block for use by cryptographic modules." "0,1"
        textline "      "
        bitfld.long 0x00 4. " ZMK_ECC_EN ,Zeroizable Master Key Error Correcting Code Check Enable Writing one to this field automatically calculates and sets the ZMK ECC value in the ZMK_ECC_VALUE field of this register." "0,1"
        textline "      "
        hexmask.long.word 0x00 7.--16. 1. " ZMK_ECC_VALUE ,Zeroizable Master Key Error Correcting Code Value This field is automatically calculated and set when one is written into ZMK_ECC_EN bit of this register."
width 7.
group.long 0x40++0x3
    line.long 0x00 "LPSVCR,SNVS_LP Security Violation Control Register"
        bitfld.long 0x00 0. " SV_EN0 ,Security Violation 0 Enable This bit enables security violation input 0." "0,1"
        textline "      "
        bitfld.long 0x00 1. " SV_EN1 ,Security Violation 1 Enable This bit enables security violation input 1." "0,1"
        textline "      "
        bitfld.long 0x00 2. " SV_EN2 ,Security Violation 2 Enable This bit enables security violation input 2." "0,1"
        textline "      "
        bitfld.long 0x00 3. " SV_EN3 ,Security Violation 3 Enable This bit enables security violation input 3." "0,1"
        textline "      "
        bitfld.long 0x00 4. " SV_EN4 ,Security Violation 4 Enable This bit enables security violation input 4." "0,1"
        textline "      "
        bitfld.long 0x00 5. " SV_EN5 ,Security Violation 5 Enable This bit enables security violation input 5." "0,1"
width 8.
group.long 0x44++0x3
    line.long 0x00 "LPTGFCR,SNVS_LP Tamper Glitch Filters Configuration Register"
        hexmask.long.byte 0x00 16.--21. 1. " ETGF1 ,External Tamper Glitch Filter 1 Configures the length of the digital glitch filter for the external tamper 1 pin between 128 and 8064 SRTC clock cycles."
        textline "       "
        bitfld.long 0x00 23. " ETGF1_EN ,External Tamper Glitch Filter 1 Enable When set, enables the external tamper glitch filter 1." "0,1"
width 7.
group.long 0x48++0x3
    line.long 0x00 "LPTDCR,SNVS_LP Tamper Detectors Configuration Register"
        bitfld.long 0x00 1. " SRTCR_EN ,SRTC Rollover Enable When set, an SRTC rollover event generates an LP security violation." "0,1"
        textline "      "
        bitfld.long 0x00 2. " MCR_EN ,MC Rollover Enable When set, an MC Rollover event generates an LP security violation." "0,1"
        textline "      "
        bitfld.long 0x00 9. " ET1_EN ,External Tampering 1 Enable When set, external tampering 1 detection generates an LP security violation." "0,1"
        textline "      "
        bitfld.long 0x00 14. " PFD_OBSERV ,System Power Fail Detector (PFD) Observability Flop The asynchronous reset input of this flop is connected directly to the inverted output of the PFD analog circuitry (external to the SNVS block)." "0,1"
        textline "      "
        bitfld.long 0x00 15. " POR_OBSERV ,Power On Reset (POR) Observability Flop The asynchronous reset input of this flop is connected directly to the output of the POR analog circuitry (external to the SNVS block)." "0,1"
width 5.
group.long 0x4c++0x3
    line.long 0x00 "LPSR,SNVS _LP Status Register"
        bitfld.long 0x00 0. " LPTA ,LP Time Alarm." "0,1"
        textline "    "
        bitfld.long 0x00 1. " SRTCR ,Secure Real Time Counter Rollover." "0,1"
        textline "    "
        bitfld.long 0x00 2. " MCR ,Monotonic Counter Rollover." "0,1"
        textline "    "
        bitfld.long 0x00 3. " PGD ,Power Supply Glitch Detected." "0,1"
        textline "    "
        bitfld.long 0x00 9. " ET1D ,External Tampering 1 Detected." "0,1"
        textline "    "
        bitfld.long 0x00 16. " ESVD ,External Security Violation Detected Indicates that a security violation is detected on one of the HP security violation ports." "0,1"
        textline "    "
        bitfld.long 0x00 17. " EO ,Emergency Off This bit is set when a power off is requested." "0,1"
        textline "    "
        bitfld.long 0x00 18. " SPO ,Set Power Off This bit is set when power off was requested by a button press, but the button was not pressed for 5 seconds." "0,1"
        textline "    "
        bitfld.long 0x00 20. " SED ,Scan Exit Detected" "0,1"
        textline "    "
        bitfld.long 0x00 30. " LPNS ,LP Section is Non-Secured Indicates that LP section was provisioned/programmed in the non-secure state." "0,1"
        textline "    "
        bitfld.long 0x00 31. " LPS ,LP Section is Secured Indicates that the LP section is provisioned/programmed in the secure or trusted state." "0,1"
width 9.
group.long 0x50++0x3
    line.long 0x00 "LPSRTCMR,SNVS_LP Secure Real Time Counter MSB Register"
        hexmask.long.word 0x00 0.--15. 1. " SRTC ,LP Secure Real Time Counter most significant 15 bits This register can be programmed only when SRTC is not active and not locked, meaning the SRTC_ENV, SRTC_SL, and SRTC_HL bits are not set."
width 9.
group.long 0x54++0x3
    line.long 0x00 "LPSRTCLR,SNVS_LP Secure Real Time Counter LSB Register"
        hexmask.long.long 0x00 0.--32. 1. " SRTC ,LP Secure Real Time Counter least significant 32 bits This register can be programmed only when SRTC is not active and not locked, meaning the SRTC_ENV, SRTC_SL, and SRTC_HL bits are not set."
width 6.
group.long 0x58++0x3
    line.long 0x00 "LPTAR,SNVS_LP Time Alarm Register"
        hexmask.long.long 0x00 0.--32. 1. " LPTA ,LP Time Alarm This register can be programmed only when the LP time alarm is disabled (LPTA_EN bit is not set)."
width 8.
group.long 0x5c++0x3
    line.long 0x00 "LPSMCMR,SNVS_LP Secure Monotonic Counter MSB Register"
        hexmask.long.word 0x00 0.--16. 1. " MON_COUNTER ,Monotonic Counter Most Significant 16 Bits The MC is incremented by one when: A write transaction to the LPSMCMR or LPSMCLR register is detected."
        textline "       "
        hexmask.long.word 0x00 16.--32. 1. " MC_ERA_BITS ,Monotonic Counter Era Bits These bits are inputs to the module and typically connect to fuses."
width 8.
group.long 0x60++0x3
    line.long 0x00 "LPSMCLR,SNVS_LP Secure Monotonic Counter LSB Register"
        hexmask.long.long 0x00 0.--32. 1. " MON_COUNTER ,Monotonic Counter bits The MC is incremented by one when: A write transaction to the LPSMCMR or LPSMCLR Register is detected."
width 7.
group.long 0x64++0x3
    line.long 0x00 "LPPGDR,SNVS _LP Power Glitch Detector Register"
        hexmask.long.long 0x00 0.--32. 1. " PGD ,Power Glitch Detector Value"
width 6.
group.long 0x68++0x3
    line.long 0x00 "LPGPR,SNVS_LP General Purpose Register"
        hexmask.long.long 0x00 0.--32. 1. " GPR ,General Purpose Register When GPR_SL or GPR_HL bit is set, the register cannot be programmed."
width 8.
group.long 0x6c++0x3
    line.long 0x00 "LPZMKR0,SNVS_LP Zeroizable Master Key Register n"
        hexmask.long.long 0x00 0.--32. 1. " ZMK ,Zeroizable Master Key Each of these registers contains part of the 256-bit ZMK value: LPZMKR0 - ZMK[ 31-0 ] LPZMKR1 - ZMK[ 63-32 ] LPZMKR2 - ZMK[ 95-64 ] LPZMKR3 - ZMK[ 127-96 ] LPZMKR4 - ZMK[ 159-128 ] LPZMKR5 - ZMK[ 191-160 ] LPZMKR6 - ZMK[ 223-192 ] LPZMKR7 - ZMK[ 255-224 ]"
width 8.
group.long 0x70++0x3
    line.long 0x00 "LPZMKR1,SNVS_LP Zeroizable Master Key Register n"
        hexmask.long.long 0x00 0.--32. 1. " ZMK ,Zeroizable Master Key Each of these registers contains part of the 256-bit ZMK value: LPZMKR0 - ZMK[ 31-0 ] LPZMKR1 - ZMK[ 63-32 ] LPZMKR2 - ZMK[ 95-64 ] LPZMKR3 - ZMK[ 127-96 ] LPZMKR4 - ZMK[ 159-128 ] LPZMKR5 - ZMK[ 191-160 ] LPZMKR6 - ZMK[ 223-192 ] LPZMKR7 - ZMK[ 255-224 ]"
width 8.
group.long 0x74++0x3
    line.long 0x00 "LPZMKR2,SNVS_LP Zeroizable Master Key Register n"
        hexmask.long.long 0x00 0.--32. 1. " ZMK ,Zeroizable Master Key Each of these registers contains part of the 256-bit ZMK value: LPZMKR0 - ZMK[ 31-0 ] LPZMKR1 - ZMK[ 63-32 ] LPZMKR2 - ZMK[ 95-64 ] LPZMKR3 - ZMK[ 127-96 ] LPZMKR4 - ZMK[ 159-128 ] LPZMKR5 - ZMK[ 191-160 ] LPZMKR6 - ZMK[ 223-192 ] LPZMKR7 - ZMK[ 255-224 ]"
width 8.
group.long 0x78++0x3
    line.long 0x00 "LPZMKR3,SNVS_LP Zeroizable Master Key Register n"
        hexmask.long.long 0x00 0.--32. 1. " ZMK ,Zeroizable Master Key Each of these registers contains part of the 256-bit ZMK value: LPZMKR0 - ZMK[ 31-0 ] LPZMKR1 - ZMK[ 63-32 ] LPZMKR2 - ZMK[ 95-64 ] LPZMKR3 - ZMK[ 127-96 ] LPZMKR4 - ZMK[ 159-128 ] LPZMKR5 - ZMK[ 191-160 ] LPZMKR6 - ZMK[ 223-192 ] LPZMKR7 - ZMK[ 255-224 ]"
width 8.
group.long 0x7c++0x3
    line.long 0x00 "LPZMKR4,SNVS_LP Zeroizable Master Key Register n"
        hexmask.long.long 0x00 0.--32. 1. " ZMK ,Zeroizable Master Key Each of these registers contains part of the 256-bit ZMK value: LPZMKR0 - ZMK[ 31-0 ] LPZMKR1 - ZMK[ 63-32 ] LPZMKR2 - ZMK[ 95-64 ] LPZMKR3 - ZMK[ 127-96 ] LPZMKR4 - ZMK[ 159-128 ] LPZMKR5 - ZMK[ 191-160 ] LPZMKR6 - ZMK[ 223-192 ] LPZMKR7 - ZMK[ 255-224 ]"
width 8.
group.long 0x80++0x3
    line.long 0x00 "LPZMKR5,SNVS_LP Zeroizable Master Key Register n"
        hexmask.long.long 0x00 0.--32. 1. " ZMK ,Zeroizable Master Key Each of these registers contains part of the 256-bit ZMK value: LPZMKR0 - ZMK[ 31-0 ] LPZMKR1 - ZMK[ 63-32 ] LPZMKR2 - ZMK[ 95-64 ] LPZMKR3 - ZMK[ 127-96 ] LPZMKR4 - ZMK[ 159-128 ] LPZMKR5 - ZMK[ 191-160 ] LPZMKR6 - ZMK[ 223-192 ] LPZMKR7 - ZMK[ 255-224 ]"
width 8.
group.long 0x84++0x3
    line.long 0x00 "LPZMKR6,SNVS_LP Zeroizable Master Key Register n"
        hexmask.long.long 0x00 0.--32. 1. " ZMK ,Zeroizable Master Key Each of these registers contains part of the 256-bit ZMK value: LPZMKR0 - ZMK[ 31-0 ] LPZMKR1 - ZMK[ 63-32 ] LPZMKR2 - ZMK[ 95-64 ] LPZMKR3 - ZMK[ 127-96 ] LPZMKR4 - ZMK[ 159-128 ] LPZMKR5 - ZMK[ 191-160 ] LPZMKR6 - ZMK[ 223-192 ] LPZMKR7 - ZMK[ 255-224 ]"
width 8.
group.long 0x88++0x3
    line.long 0x00 "LPZMKR7,SNVS_LP Zeroizable Master Key Register n"
        hexmask.long.long 0x00 0.--32. 1. " ZMK ,Zeroizable Master Key Each of these registers contains part of the 256-bit ZMK value: LPZMKR0 - ZMK[ 31-0 ] LPZMKR1 - ZMK[ 63-32 ] LPZMKR2 - ZMK[ 95-64 ] LPZMKR3 - ZMK[ 127-96 ] LPZMKR4 - ZMK[ 159-128 ] LPZMKR5 - ZMK[ 191-160 ] LPZMKR6 - ZMK[ 223-192 ] LPZMKR7 - ZMK[ 255-224 ]"
width 8.
rgroup.long 0xbf8++0x3
    line.long 0x00 "HPVIDR1,SNVS _HP Version ID Register 1"
        hexmask.long.byte 0x00 0.--8. 1. " MINOR_REV ,SNVS block minor version number"
        textline "       "
        hexmask.long.byte 0x00 8.--16. 1. " MAJOR_REV ,SNVS block major version number"
        textline "       "
        hexmask.long.word 0x00 16.--32. 1. " IP_ID ,SNVS block ID"
width 8.
rgroup.long 0xbfc++0x3
    line.long 0x00 "HPVIDR2,SNVS _HP Version ID Register 2"
        hexmask.long.byte 0x00 0.--8. 1. " CONFIG_OPT ,SNVS Configuration Option"
        textline "       "
        hexmask.long.byte 0x00 8.--16. 1. " ECO_REV ,SNVS ECO Revision"
        textline "       "
        hexmask.long.byte 0x00 16.--24. 1. " INTG_OPT ,SNVS Integration Option"


tree.end



;--------------------------------------------------------------------------------
; SPBA
;--------------------------------------------------------------------------------
tree "SPBA"
    base ad:0x0203c000

width 5.
group.long 0x0++0x3
    line.long 0x00 "PRR0,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 5.
group.long 0x4++0x3
    line.long 0x00 "PRR1,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 5.
group.long 0x8++0x3
    line.long 0x00 "PRR2,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 5.
group.long 0xc++0x3
    line.long 0x00 "PRR3,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 5.
group.long 0x10++0x3
    line.long 0x00 "PRR4,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 5.
group.long 0x14++0x3
    line.long 0x00 "PRR5,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 5.
group.long 0x18++0x3
    line.long 0x00 "PRR6,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 5.
group.long 0x1c++0x3
    line.long 0x00 "PRR7,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 5.
group.long 0x20++0x3
    line.long 0x00 "PRR8,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 5.
group.long 0x24++0x3
    line.long 0x00 "PRR9,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "    "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "    "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x28++0x3
    line.long 0x00 "PRR10,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x2c++0x3
    line.long 0x00 "PRR11,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x30++0x3
    line.long 0x00 "PRR12,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x34++0x3
    line.long 0x00 "PRR13,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x38++0x3
    line.long 0x00 "PRR14,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x3c++0x3
    line.long 0x00 "PRR15,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x40++0x3
    line.long 0x00 "PRR16,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x44++0x3
    line.long 0x00 "PRR17,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x48++0x3
    line.long 0x00 "PRR18,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x4c++0x3
    line.long 0x00 "PRR19,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x50++0x3
    line.long 0x00 "PRR20,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x54++0x3
    line.long 0x00 "PRR21,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x58++0x3
    line.long 0x00 "PRR22,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x5c++0x3
    line.long 0x00 "PRR23,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x60++0x3
    line.long 0x00 "PRR24,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x64++0x3
    line.long 0x00 "PRR25,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x68++0x3
    line.long 0x00 "PRR26,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x6c++0x3
    line.long 0x00 "PRR27,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x70++0x3
    line.long 0x00 "PRR28,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x74++0x3
    line.long 0x00 "PRR29,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x78++0x3
    line.long 0x00 "PRR30,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."
width 6.
group.long 0x7c++0x3
    line.long 0x00 "PRR31,Peripheral Rights Register"
        bitfld.long 0x00 0. " RARA ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 1. " RARB ,Resource Access Right." "0,1"
        textline "     "
        bitfld.long 0x00 2. " RARC ,Resource Access Right." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--18. 1. " ROI ,Resource Owner ID."
        textline "     "
        hexmask.long.byte 0x00 30.--32. 1. " RMO ,Requesting Master Owner."


tree.end



;--------------------------------------------------------------------------------
; SPDC
;--------------------------------------------------------------------------------
tree "SPDC"
    base ad:0x020e8000

width 13.
group.long 0x0++0x3
    line.long 0x00 "DISP_TRIGGER,Display Trigger"
        bitfld.long 0x00 0. " DISP_TRIG ,EPD screen update trigger When set to ""1"" it will trigger TCON start to display image on panel." "0,1"
        textline "            "
        hexmask.long.byte 0x00 1.--4. 1. " EPD_MODE ,EPD update mode setting 0x0 MODE_0 - It will be displayed with mode 0 waveform 0x1 MODE_1 - It will be displayed with mode 1 waveform 0x2 MODE_2 - It will be displayed with mode 2 waveform 0x3 MODE_3 - It will be displayed with mode 3 waveform 0x4 MODE_4 - It will be displayed with mode 4 waveform (High Speed Handwriting Mode) 0x5 MODE_5 - It will be displayed with mode 5 waveform 0x7 MODE_7 - It will be displayed with mode 7 waveform"
        textline "            "
        bitfld.long 0x00 4. " FLASH_SET ,Judge EPD screen update will be flashed or not in mode 7 0x0 NO_FLASH - It will not be flashed screen update in mode 7 0x1 FLASH - It will be flashed screen update in mode 7" "0,1"
width 11.
group.long 0x4++0x3
    line.long 0x00 "UPDATE_X_Y,Display Coordinate"
        hexmask.long.word 0x00 0.--12. 1. " COORDINATE_Y ,Vertical coordinate of update region (minimum: 1) If image have rotated counterclockwise 90 Y should be 4n + 1 format where n is integer"
        textline "          "
        hexmask.long.word 0x00 16.--28. 1. " COORDINATE_X ,Horizontal coordinate of update region (minimum: 1) X should be 4n + 1 format where n is integer"
width 11.
group.long 0x8++0x3
    line.long 0x00 "UPDATE_W_H,Display Area Size"
        hexmask.long.word 0x00 0.--12. 1. " HEIGHT ,Height of update region If image have rotated counterclockwise 90 L should be 4n format where n is integer"
        textline "          "
        hexmask.long.word 0x00 16.--28. 1. " WIDTH ,Width of update region W should be 4n format where n is integer"
width 16.
group.long 0xc++0x3
    line.long 0x00 "LUT_PARA_UPDATE,LUT Parameter Update"
        hexmask.long.byte 0x00 0.--8. 1. " LUT_PARAMETER_UPDATED_VALUE ,The value of update LUT parameter"
        textline "               "
        hexmask.long.byte 0x00 8.--16. 1. " LUT_PARAMETER_UPDATED_ADDR ,The address of updated LUT parameter"
width 8.
group.long 0x10++0x3
    line.long 0x00 "OPERATE,Display Normal Operation"
        bitfld.long 0x00 0. " DISP_REFRESH ,Display refresh When set to ""1"" it will trigger TCON start to refresh panel screen base on DDR image data (current frame memory) with mode 0 waveform." "0,1"
        textline "       "
        bitfld.long 0x00 1. " DEEP_REFRESH ,Deep refresh (combine display reset and display refresh function) When set to ""1"" it will trigger TCON start to reset panel screen and automatic refresh panel screen base on DDR image data (current frame memory) with mode 0 waveform." "0,1"
        textline "       "
        bitfld.long 0x00 2. " DISP_RESET ,Display reset When set to ""1"" it will trigger TCON start to reset panel screen and automatic update next/current/previous frame memories according to flash LUT setting gray level." "0,1"
        textline "       "
        bitfld.long 0x00 31. " SW_TCON_RESET ,Software TCON register reset When set to ""1"" it will trigger TCON start to reset all internal registers in TCON." "0,1"
width 15.
group.long 0x14++0x3
    line.long 0x00 "PANEL_INIT_SET,SPDC Initial Setting"
        bitfld.long 0x00 0. " YOE_POL ,Set the YOE signal's polarity of gate driver IC 0x0 LOW_ENABLE -Gate pulse outputs low enable." "0,1"
        textline "              "
        bitfld.long 0x00 1. " DUAL_GATE ,Set to enable the panel type of dual gate driver 0x0 SINGLE_GATE -Single gate driver (support gate driver K7900)." "0,1"
        textline "              "
        hexmask.long.byte 0x00 2.--7. 1. " RESOLUTION ,Set the panel resolution GRAY_MODE - Please reference the Table 45-12 RGBW_MODE -Please reference the Table 45-13"
        textline "              "
        bitfld.long 0x00 7. " UD ,Select gate driver IC scanning direction up or down." "0,1"
        textline "              "
        bitfld.long 0x00 8. " RL ,Select source driver IC scanning direction right or left." "0,1"
        textline "              "
        bitfld.long 0x00 9. " DATA_FILTER_N ,Automatic filter input image pixel data base on the display mode 0x0 ENABLE_AUTO_DATA_FILTER -Filter input data 16-step gray to 4-step gray data for mode 2 and mode 3." "0,1"
        textline "              "
        bitfld.long 0x00 10. " POWER_READY ,Driver IC power ready signal 0x0 POWER_NOT_READY - The TCON will be hold wait for driver IC power turn on finish 0x1 POWER_READY - The TCON will into IDLE state and user cloud send the display trigger" "0,1"
        textline "              "
        bitfld.long 0x00 11. " RGBW_MODE_EN ,RGBW color mode enable 0x0 DISABLE_RGBW_MODE -It will enable TCON into gray mode 0x1 ENABLE_ RGBW_MODE - It will enable TCON into RGBW mode" "0,1"
        textline "              "
        bitfld.long 0x00 13. " HBURST_LEN_EN ,HBURST length enable 0x0 DISABLE_HBURST - AHB2AXI gasket ignores the HBURST_LEN[3:0]." "0,1"
width 15.
group.long 0x18++0x3
    line.long 0x00 "TEMPER_SETTING,Environment Temperature"
        hexmask.long.word 0x00 0.--9. 1. " TEMPERATURE ,Update TCON temperature information Temperature Information is used to indicate the temperature of operating environment."
width 9.
group.long 0x1c++0x3
    line.long 0x00 "NEXT_BUF,Next Frame Memory Address"
        hexmask.long.long 0x00 0.--32. 1. " NEXT_FRAME_MEMORY_ADDR ,Update next frame memory address of DDR memory The next frame memory address should be word-align value, it means EPD TCON wills automatic truncate two bits of LSB."
width 12.
group.long 0x20++0x3
    line.long 0x00 "CURRENT_BUF,Current Frame Memory Address"
        hexmask.long.long 0x00 0.--32. 1. " CURRENT_FRAME_MEMORY_ADDR ,Update current frame memory address of DDR memory The current frame memory address should be word-align value, it means EPD TCON wills automatic truncate two bits of LSB."
width 14.
group.long 0x24++0x3
    line.long 0x00 "PREVIOUS_BUFF,Previous Frame Memory Address"
        hexmask.long.long 0x00 0.--32. 1. " PREVIOUS_FRAME_MEMORY_ADDR ,Update previous frame memory address of DDR memory The previous frame memory address should be word-align value, it means EPD TCON wills automatic truncate two bits of LSB."
width 13.
group.long 0x28++0x3
    line.long 0x00 "FRM_CNT_BUFF,Counter Frame Memory Address"
        hexmask.long.long 0x00 0.--32. 1. " COUNTER_FRAME_MEMORY_ADDR ,Update counter frame memory address of DDR memory The counter frame memory address should be word-align value, it means EPD TCON wills automatic truncate two bits of LSB."
width 9.
group.long 0x2c++0x3
    line.long 0x00 "LUT_BUFF,LUT Memory Address"
        hexmask.long.long 0x00 0.--32. 1. " LUT_MEMORY_ADDR ,Update LUT memory address of DDR memory The LUT memory address should be word-align value, it means EPD TCON wills automatic truncate two bits of LSB."
width 7.
group.long 0x30++0x3
    line.long 0x00 "INT_EN,Interrupt Enable"
        bitfld.long 0x00 0. " UPDATE_FINISH_INT_EN ,Screen update finish interrupt signal mask 0x0 DISABLE_UPDATE_FINISH_INTERRUPT - Disable Frame Update Finish Interrupt 0x1 ENABLE_UPDATE_FINISH_INTERRUPT - Enable Frame Update Finish Interrupt" "0,1"
        textline "      "
        bitfld.long 0x00 1. " TCON_INIT_FINISH_INT_EN ,TCON initialization finish interrupt signal mask 0x0 DISABLE_TCON_INIT_FINISH_INTERRUPT - Disable TCON Initialization Finish Interrupt 0x1 ENABLE_TCON_INIT_FINISH_INTERRUPT - Enable TCON Initialization Interrupt" "0,1"
        textline "      "
        bitfld.long 0x00 2. " LUT_DOWNLOAD_FINISH_INT_EN ,LUT initial download finish interrupt signal mask 0x0 DISABLE_LUT_DOWNLOAD_FINISH_INTERRUPT - Disable LUT initial Download Finish Interrupt 0x1 ENABLE_LUT_DOWNLOAD_FINISH_INTERRUPT - Enable LUT initial Download Finish Interrupt" "0,1"
        textline "      "
        bitfld.long 0x00 3. " TCON_ERROR_INT_EN ,Error interrupt signal mask 0x0 DISABLE_ERRPR_INTERRUPT - Disable Error Interrupt 0x1 ENABLE_ERRPR_INTERRUPT - Enable Error Interrupt" "0,1"
width 11.
group.long 0x34++0x3
    line.long 0x00 "INT_ST_CLR,Interrupt Status & Clear"
        bitfld.long 0x00 0. " UPDATE_FINISH_INT_CLR ,Screen update finish interrupt signal clear When set to ""1"" it will trigger TCON start to clear screen update finish interrupt." "0,1"
        textline "          "
        bitfld.long 0x00 1. " TCON_INIT_FINISH_INT_CLR ,TCON initialization finish interrupt signal clear When set to ""1"" it will trigger TCON start to clear TCON initialization finish interrupt." "0,1"
        textline "          "
        bitfld.long 0x00 2. " LUT_DOWNLOAD_FINISH_INT_CLR ,LUT initial download finish interrupt signal clear When set to ""1"" it will trigger TCON start to clear LUT download finish interrupt." "0,1"
        textline "          "
        bitfld.long 0x00 3. " TCON_ERROR_INT_CLR ,Error interrupt signal clear When set to ""1"" it will trigger TCON start to clear error interrupt." "0,1"
width 7.
rgroup.long 0x3c++0x3
    line.long 0x00 "STATUS,SPDC Operation Status"
        bitfld.long 0x00 0. " EPD_TCON_BUSY_N ,EPD TCON busy status 0x0 BUSY_STATUS - Panel is under updating 0x1 NOT_BUSY_STATUS - Panel update finished" "0,1"
        textline "      "
        bitfld.long 0x00 3. " LUT_CHECKSUM ,LUT checksum status 0x0 CHECKSUM_FAIL - LUT checksum fail 0x1 CHECKSUM_SUCCESS - LUT checksum pass" "0,1"
        textline "      "
        hexmask.long.byte 0x00 4.--8. 1. " EPD_TCON_STATUS ,EPD TCON IP status 0x0 RST_STATUS - EPD TCON during reset phase 0x1 WAIT_FOR_CHECKSUM_AND_POWER_READY_STATUS - EPD TCON is hold for waiting checksum pass and driver IC power ready 0x2 CHECKSUM_FAIL_BUT_POWER_READY_STATUS - EPD TCON checksum fail but driver IC power ready."
width 15.
rgroup.long 0x40++0x3
    line.long 0x00 "PANEL_TYPE_VER,Panel Type Related Information"
        hexmask.long.word 0x00 0.--16. 1. " PRODUCT_AND_DRIVER_ID ,Product ID and driver ID, they are stand for different type of panel 0x0 A060SE02 - Panel type (AUO-K7900) 0x1 A090XE01 - Panel type (AUO-K7900) Others need to be defined"
        textline "              "
        hexmask.long.byte 0x00 16.--24. 1. " LUT_VERSION ,LUT version, it stands for different version of driving waveform 0x0101 V308 - Driving waveform type 0x0102 V312 - Driving waveform type Others need to be defined"
        textline "              "
        hexmask.long.byte 0x00 24.--32. 1. " EPD_PANEL_TYPE ,EPD panel type, it stands for different material type of film."
width 9.
rgroup.long 0x44++0x3
    line.long 0x00 "TCON_VER,SPDC IP Version"
        hexmask.long.byte 0x00 0.--8. 1. " EPD_TCON_VERSION ,EPD TCON version, it stands for different version of EPD TCON."
width 12.
group.long 0x48++0x3
    line.long 0x00 "SW_GATE_CLK,All Clock Gating Enable"
        bitfld.long 0x00 0. " GATING_ALL_CLK_EN ,All clocks gating enable 0x0 ENABLE_ALL_CLOCKS - All clocks free run 0x1 GATING_ALL_CLOCKS - Gating all clocks for low power" "0,1"


tree.end



;--------------------------------------------------------------------------------
; SPDIF
;--------------------------------------------------------------------------------
tree "SPDIF"
    base ad:0x02004000

width 4.
group.long 0x0++0x3
    line.long 0x00 "SCR,SPDIF Configuration Register"
        hexmask.long.byte 0x00 0.--2. 1. " USRC_SEL ,"
        textline "   "
        hexmask.long.byte 0x00 2.--5. 1. " TXSEL ,"
        textline "   "
        bitfld.long 0x00 5. " VALCTRL ," "0,1"
        textline "   "
        bitfld.long 0x00 8. " DMA_TX_EN ,DMA Transmit Request Enable (Tx FIFO empty)" "0,1"
        textline "   "
        bitfld.long 0x00 9. " DMA_RX_EN ,DMA Receive Request Enable (RX FIFO full)" "0,1"
        textline "   "
        hexmask.long.byte 0x00 10.--12. 1. " TXFIFO_CTRL ,"
        textline "   "
        bitfld.long 0x00 12. " SOFT_RESET ,When write 1 to this bit, it will cause SPDIF software reset." "0,1"
        textline "   "
        bitfld.long 0x00 13. " LOW_POWER ,When write 1 to this bit, it will cause SPDIF enter low-power mode." "0,1"
        textline "   "
        hexmask.long.byte 0x00 15.--17. 1. " TXFIFOEMPTY_SEL ,"
        textline "   "
        bitfld.long 0x00 17. " TXAUTOSYNC ," "0,1"
        textline "   "
        bitfld.long 0x00 18. " RXAUTOSYNC ," "0,1"
        textline "   "
        hexmask.long.byte 0x00 19.--21. 1. " RXFIFOFULL_SEL ,"
        textline "   "
        bitfld.long 0x00 21. " RXFIFO_RST ," "0,1"
        textline "   "
        bitfld.long 0x00 22. " RXFIFO_OFF_ON ," "0,1"
        textline "   "
        bitfld.long 0x00 23. " RXFIFO_CTRL ," "0,1"
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 5.
group.long 0x4++0x3
    line.long 0x00 "SRCD,CDText Control Register"
        bitfld.long 0x00 1. " USYNCMODE ," "0,1"
        textline "    "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 5.
group.long 0x8++0x3
    line.long 0x00 "SRPC,PhaseConfig Register"
        hexmask.long.byte 0x00 3.--6. 1. " GAINSEL ,Gain selection:"
        textline "    "
        bitfld.long 0x00 6. " LOCK ,LOCK bit to show that the internal DPLL is locked, read only" "0,1"
        textline "    "
        hexmask.long.byte 0x00 7.--11. 1. " CLKSRC_SEL ,Clock source selection, all other settings not shown are reserved:"
        textline "    "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 4.
group.long 0xc++0x3
    line.long 0x00 "SIE,InterruptEn Register"
        bitfld.long 0x00 0. " RXFIFOFUL ,SPDIF Rx FIFO full, can't be cleared with reg." "0,1"
        textline "   "
        bitfld.long 0x00 1. " TXEM ,SPDIF Tx FIFO empty, can't be cleared with reg." "0,1"
        textline "   "
        bitfld.long 0x00 2. " LOCKLOSS ,SPDIF receiver loss of lock" "0,1"
        textline "   "
        bitfld.long 0x00 3. " RXFIFORESYN ,Rx FIFO resync" "0,1"
        textline "   "
        bitfld.long 0x00 4. " RXFIFOUNOV ,Rx FIFO underrun/overrun" "0,1"
        textline "   "
        bitfld.long 0x00 5. " UQERR ,U/Q Channel framing error" "0,1"
        textline "   "
        bitfld.long 0x00 6. " UQSYNC ,U/Q Channel sync found" "0,1"
        textline "   "
        bitfld.long 0x00 7. " QRXOV ,Q Channel receive register overrun" "0,1"
        textline "   "
        bitfld.long 0x00 8. " QRXFUL ,Q Channel receive register full, can't be cleared with reg." "0,1"
        textline "   "
        bitfld.long 0x00 9. " URXOV ,U Channel receive register overrun" "0,1"
        textline "   "
        bitfld.long 0x00 10. " URXFUL ,U Channel receive register full, can't be cleared with reg." "0,1"
        textline "   "
        bitfld.long 0x00 14. " BITERR ,SPDIF receiver found parity bit error" "0,1"
        textline "   "
        bitfld.long 0x00 15. " SYMERR ,SPDIF receiver found illegal symbol" "0,1"
        textline "   "
        bitfld.long 0x00 16. " VALNOGOOD ,SPDIF validity flag no good" "0,1"
        textline "   "
        bitfld.long 0x00 17. " CNEW ,SPDIF receive change in value of control channel" "0,1"
        textline "   "
        bitfld.long 0x00 18. " TXRESYN ,SPDIF Tx FIFO resync" "0,1"
        textline "   "
        bitfld.long 0x00 19. " TXUNOV ,SPDIF Tx FIFO under/overrun" "0,1"
        textline "   "
        bitfld.long 0x00 20. " LOCK ,SPDIF receiver's DPLL is locked" "0,1"
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 4.
rgroup.long 0x10++0x3
    line.long 0x00 "SIS,InterruptStat Register"
        bitfld.long 0x00 0. " RXFIFOFUL ,SPDIF Rx FIFO full, can't be cleared with reg." "0,1"
        textline "   "
        bitfld.long 0x00 1. " TXEM ,SPDIF Tx FIFO empty, can't be cleared with reg." "0,1"
        textline "   "
        bitfld.long 0x00 2. " LOCKLOSS ,SPDIF receiver loss of lock" "0,1"
        textline "   "
        bitfld.long 0x00 3. " RXFIFORESYN ,Rx FIFO resync" "0,1"
        textline "   "
        bitfld.long 0x00 4. " RXFIFOUNOV ,Rx FIFO underrun/overrun" "0,1"
        textline "   "
        bitfld.long 0x00 5. " UQERR ,U/Q Channel framing error" "0,1"
        textline "   "
        bitfld.long 0x00 6. " UQSYNC ,U/Q Channel sync found" "0,1"
        textline "   "
        bitfld.long 0x00 7. " QRXOV ,Q Channel receive register overrun" "0,1"
        textline "   "
        bitfld.long 0x00 8. " QRXFUL ,Q Channel receive register full, can't be cleared with reg." "0,1"
        textline "   "
        bitfld.long 0x00 9. " URXOV ,U Channel receive register overrun" "0,1"
        textline "   "
        bitfld.long 0x00 10. " URXFUL ,U Channel receive register full, can't be cleared with reg." "0,1"
        textline "   "
        bitfld.long 0x00 14. " BITERR ,SPDIF receiver found parity bit error" "0,1"
        textline "   "
        bitfld.long 0x00 15. " SYMERR ,SPDIF receiver found illegal symbol" "0,1"
        textline "   "
        bitfld.long 0x00 16. " VALNOGOOD ,SPDIF validity flag no good" "0,1"
        textline "   "
        bitfld.long 0x00 17. " CNEW ,SPDIF receive change in value of control channel" "0,1"
        textline "   "
        bitfld.long 0x00 18. " TXRESYN ,SPDIF Tx FIFO resync" "0,1"
        textline "   "
        bitfld.long 0x00 19. " TXUNOV ,SPDIF Tx FIFO under/overrun" "0,1"
        textline "   "
        bitfld.long 0x00 20. " LOCK ,SPDIF receiver's DPLL is locked" "0,1"
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 4.
wgroup.long 0x10++0x3
    line.long 0x00 "SIC,InterruptClear Register"
        bitfld.long 0x00 2. " LOCKLOSS ,SPDIF receiver loss of lock" "0,1"
        textline "   "
        bitfld.long 0x00 3. " RXFIFORESYN ,Rx FIFO resync" "0,1"
        textline "   "
        bitfld.long 0x00 4. " RXFIFOUNOV ,Rx FIFO underrun/overrun" "0,1"
        textline "   "
        bitfld.long 0x00 5. " UQERR ,U/Q Channel framing error" "0,1"
        textline "   "
        bitfld.long 0x00 6. " UQSYNC ,U/Q Channel sync found" "0,1"
        textline "   "
        bitfld.long 0x00 7. " QRXOV ,Q Channel receive register overrun" "0,1"
        textline "   "
        bitfld.long 0x00 9. " URXOV ,U Channel receive register overrun" "0,1"
        textline "   "
        bitfld.long 0x00 14. " BITERR ,SPDIF receiver found parity bit error" "0,1"
        textline "   "
        bitfld.long 0x00 15. " SYMERR ,SPDIF receiver found illegal symbol" "0,1"
        textline "   "
        bitfld.long 0x00 16. " VALNOGOOD ,SPDIF validity flag no good" "0,1"
        textline "   "
        bitfld.long 0x00 17. " CNEW ,SPDIF receive change in value of control channel" "0,1"
        textline "   "
        bitfld.long 0x00 18. " TXRESYN ,SPDIF Tx FIFO resync" "0,1"
        textline "   "
        bitfld.long 0x00 19. " TXUNOV ,SPDIF Tx FIFO under/overrun" "0,1"
        textline "   "
        bitfld.long 0x00 20. " LOCK ,SPDIF receiver's DPLL is locked" "0,1"
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 4.
rgroup.long 0x14++0x3
    line.long 0x00 "SRL,SPDIFRxLeft Register"
        hexmask.long.long 0x00 0.--24. 1. " RXDATALEFT ,Processor receive SPDIF data left"
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 4.
rgroup.long 0x18++0x3
    line.long 0x00 "SRR,SPDIFRxRight Register"
        hexmask.long.long 0x00 0.--24. 1. " RXDATARIGHT ,Processor receive SPDIF data right"
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 6.
rgroup.long 0x1c++0x3
    line.long 0x00 "SRCSH,SPDIFRxCChannel_h Register"
        hexmask.long.long 0x00 0.--24. 1. " RXCCHANNEL_H ,SPDIF receive C channel register, contains first 24 bits of C channel without interpretation"
        textline "     "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 6.
rgroup.long 0x20++0x3
    line.long 0x00 "SRCSL,SPDIFRxCChannel_l Register"
        hexmask.long.long 0x00 0.--24. 1. " RXCCHANNEL_L ,SPDIF receive C channel register, contains next 24 bits of C channel without interpretation"
        textline "     "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 4.
rgroup.long 0x24++0x3
    line.long 0x00 "SRU,UchannelRx Register"
        hexmask.long.long 0x00 0.--24. 1. " RXUCHANNEL ,SPDIF receive U channel register, contains next 3 U channel bytes"
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,This is a 24-bit register the upper byte is unimplemented."
width 4.
rgroup.long 0x28++0x3
    line.long 0x00 "SRQ,QchannelRx Register"
        hexmask.long.long 0x00 0.--24. 1. " RXQCHANNEL ,SPDIF receive Q channel register, contains next 3 Q channel bytes"
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 4.
wgroup.long 0x2c++0x3
    line.long 0x00 "STL,SPDIFTxLeft Register"
        hexmask.long.long 0x00 0.--24. 1. " TXDATALEFT ,SPDIF transmit left channel data."
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,This is a 24-bit register the upper byte is unimplemented."
width 4.
wgroup.long 0x30++0x3
    line.long 0x00 "STR,SPDIFTxRight Register"
        hexmask.long.long 0x00 0.--24. 1. " TXDATARIGHT ,SPDIF transmit right channel data."
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,This is a 24-bit register the upper byte is unimplemented."
width 7.
group.long 0x34++0x3
    line.long 0x00 "STCSCH,SPDIFTxCChannelCons_h Register"
        hexmask.long.long 0x00 0.--24. 1. " TXCCHANNELCONS_H ,SPDIF transmit Cons."
        textline "      "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 7.
group.long 0x38++0x3
    line.long 0x00 "STCSCL,SPDIFTxCChannelCons_l Register"
        hexmask.long.long 0x00 0.--24. 1. " TXCCHANNELCONS_L ,SPDIF transmit Cons."
        textline "      "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 5.
rgroup.long 0x44++0x3
    line.long 0x00 "SRFM,FreqMeas Register"
        hexmask.long.long 0x00 0.--24. 1. " FREQMEAS ,Frequency measurement data"
        textline "    "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"
width 4.
group.long 0x50++0x3
    line.long 0x00 "STC,SPDIFTxClk Register"
        hexmask.long.byte 0x00 0.--7. 1. " TXCLK_DF ,Divider factor (1-128)"
        textline "   "
        bitfld.long 0x00 7. " TX_ALL_CLK_EN ,Spdif transfer clock enable.When data is going to be transfered, this bit should be set to1." "0,1"
        textline "   "
        hexmask.long.byte 0x00 8.--11. 1. " TXCLK_SOURCE ,"
        textline "   "
        hexmask.long.word 0x00 11.--20. 1. " SYSCLK_DF ,system clock divider factor, 2~512."
        textline "   "
        hexmask.long.byte 0x00 24.--32. 1. " UNIMPLEMENTED ,"


tree.end



;--------------------------------------------------------------------------------
; SRC
;--------------------------------------------------------------------------------
tree "SRC"
    base ad:0x020d8000

width 4.
group.long 0x0++0x3
    line.long 0x00 "SCR,SRC Control Register"
        bitfld.long 0x00 0. " WARM_RESET_ENABLE ,WARM reset enable bit." "0,1"
        textline "   "
        bitfld.long 0x00 1. " SW_GPU_RST ,Software reset for gpu this is a self clearing bit." "0,1"
        textline "   "
        bitfld.long 0x00 2. " SW_VPU_RST ,Software reset for vpu this is a self clearing bit." "0,1"
        textline "   "
        bitfld.long 0x00 4. " SW_OPEN_VG_RST ,Software reset for open_vg This is a self clearing bit." "0,1"
        textline "   "
        hexmask.long.byte 0x00 5.--7. 1. " WARM_RST_BYPASS_COUNT ,Defines the ckil cycles to count before bypassing the MMDC acknowledge for WARM reset."
        textline "   "
        hexmask.long.byte 0x00 7.--11. 1. " MASK_WDOG_RST ,Mask wdog_rst_b source."
        textline "   "
        bitfld.long 0x00 11. " EIM_RST ,EIM reset is needed in order to reconfigure the eim chip select." "0,1"
        textline "   "
        bitfld.long 0x00 13. " CORE0_RST ,Software reset for core0 only." "0,1"
        textline "   "
        bitfld.long 0x00 17. " CORE0_DBG_RST ,Software reset for core0 debug only." "0,1"
        textline "   "
        bitfld.long 0x00 21. " CORES_DBG_RST ,Software reset for debug of arm platform only." "0,1"
        textline "   "
        bitfld.long 0x00 25. " DBG_RST_MSK_PG ,Do not assert debug resets after power gating event of cpu" "0,1"
width 6.
rgroup.long 0x4++0x3
    line.long 0x00 "SBMR1,SRC Boot Mode Register 1"
        hexmask.long.byte 0x00 0.--8. 1. " BOOT_CFG1 ,Please refer to fuse map."
        textline "     "
        hexmask.long.byte 0x00 8.--16. 1. " BOOT_CFG2 ,Please refer to fuse map."
        textline "     "
        hexmask.long.byte 0x00 16.--24. 1. " BOOT_CFG3 ,Please refer to fuse map."
        textline "     "
        hexmask.long.byte 0x00 24.--32. 1. " BOOT_CFG4 ,Please refer to fuse map."
width 5.
group.long 0x8++0x3
    line.long 0x00 "SRSR,SRC Reset Status Register"
        bitfld.long 0x00 0. " IPP_RESET_B ,Indicates whether reset was the result of ipp_reset_b pin (Power-up sequence)" "0,1"
        textline "    "
        bitfld.long 0x00 2. " CSU_RESET_B ,Indicates whether the reset was the result of the csu_reset_b input." "0,1"
        textline "    "
        bitfld.long 0x00 3. " IPP_USER_RESET_B ,Indicates whether the reset was the result of the ipp_user_reset_b qualified reset." "0,1"
        textline "    "
        bitfld.long 0x00 4. " WDOG_RST_B ,IC Watchdog Time-out reset." "0,1"
        textline "    "
        bitfld.long 0x00 5. " JTAG_RST_B ,HIGH - Z JTAG reset." "0,1"
        textline "    "
        bitfld.long 0x00 6. " JTAG_SW_RST ,JTAG SW reset." "0,1"
        textline "    "
        bitfld.long 0x00 16. " WARM_BOOT ,WARM boot indication shows that WARM boot was initiated by software." "0,1"
width 5.
rgroup.long 0x14++0x3
    line.long 0x00 "SISR,SRC Interrupt Status Register"
        bitfld.long 0x00 0. " GPU_PASSED_RESET ,Interrupt generated to indicate that gpu passed software reset and is ready to be used" "0,1"
        textline "    "
        bitfld.long 0x00 1. " VPU_PASSED_RESET ,Interrupt generated to indicate that vpu passed software reset and is ready to be used" "0,1"
        textline "    "
        bitfld.long 0x00 3. " OPEN_VG_PASSED_RESET ,Interrupt generated to indicate that open_vg passed software reset and is ready to be used" "0,1"
        textline "    "
        bitfld.long 0x00 5. " CORE0_WDOG_RST_REQ ,WDOG reset request from CPU core0." "0,1"
width 5.
group.long 0x18++0x3
    line.long 0x00 "SIMR,SRC Interrupt Mask Register"
        bitfld.long 0x00 0. " MASK_GPU_PASSED_RESET ,mask interrupt generation due to gpu passed reset" "0,1"
        textline "    "
        bitfld.long 0x00 1. " MASK_VPU_PASSED_RESET ,mask interrupt generation due to vpu passed reset" "0,1"
        textline "    "
        bitfld.long 0x00 3. " MASK_OPEN_VG_PASSED_RESET ,mask interrupt generation due to open_vg passed reset" "0,1"
width 6.
rgroup.long 0x1c++0x3
    line.long 0x00 "SBMR2,SRC Boot Mode Register 2"
        hexmask.long.byte 0x00 0.--2. 1. " SEC_CONFIG ,Please refer to fuse map."
        textline "     "
        bitfld.long 0x00 3. " DIR_BT_DIS ,Please refer to fuse map." "0,1"
        textline "     "
        bitfld.long 0x00 4. " BT_FUSE_SEL ,BT_FUSE_SEL (connected to gpio bt_fuse_sel)" "0,1"
        textline "     "
        hexmask.long.byte 0x00 24.--26. 1. " BMOD ,Please refer to fuse map."
        textline "     "
        hexmask.long.byte 0x00 27.--30. 1. " TEST_MODE ,Please refer to fuse map."
width 5.
group.long 0x20++0x3
    line.long 0x00 "GPR1,SRC General Purpose Register 1"
width 5.
group.long 0x24++0x3
    line.long 0x00 "GPR2,SRC General Purpose Register 2"
width 5.
group.long 0x28++0x3
    line.long 0x00 "GPR3,SRC General Purpose Register 3"
width 5.
group.long 0x2c++0x3
    line.long 0x00 "GPR4,SRC General Purpose Register 4"
width 5.
group.long 0x30++0x3
    line.long 0x00 "GPR5,SRC General Purpose Register 5"
width 5.
group.long 0x34++0x3
    line.long 0x00 "GPR6,SRC General Purpose Register 6"
width 5.
group.long 0x38++0x3
    line.long 0x00 "GPR7,SRC General Purpose Register 7"
width 5.
group.long 0x3c++0x3
    line.long 0x00 "GPR8,SRC General Purpose Register 8"
width 5.
group.long 0x40++0x3
    line.long 0x00 "GPR9,SRC General Purpose Register 9"
width 6.
group.long 0x44++0x3
    line.long 0x00 "GPR10,SRC General Purpose Register 10"


tree.end



;--------------------------------------------------------------------------------
; SSI
;--------------------------------------------------------------------------------
tree.open "SSI"
    tree "SSI1"
        base ad:0x02028000

width 5.
group.long 0x0++0x3
    line.long 0x00 "STX0,SSI Transmit Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " STXN ,SSI Transmit Data."
width 5.
group.long 0x4++0x3
    line.long 0x00 "STX1,SSI Transmit Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " STXN ,SSI Transmit Data."
width 5.
rgroup.long 0x8++0x3
    line.long 0x00 "SRX0,SSI Receive Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " SRXN ,SSI Receive Data."
width 5.
rgroup.long 0xc++0x3
    line.long 0x00 "SRX1,SSI Receive Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " SRXN ,SSI Receive Data."
width 4.
group.long 0x10++0x3
    line.long 0x00 "SCR,SSI Control Register"
        bitfld.long 0x00 0. " SSIEN ,SSIEN - SSI Enable This bit is used to enable/disable the SSI." "0,1"
        textline "   "
        bitfld.long 0x00 1. " TE ,Transmit Enable." "0,1"
        textline "   "
        bitfld.long 0x00 2. " RE ,Receive Enable." "0,1"
        textline "   "
        bitfld.long 0x00 3. " NET ,Network Mode." "0,1"
        textline "   "
        bitfld.long 0x00 4. " SYN ,Synchronous Mode." "0,1"
        textline "   "
        hexmask.long.byte 0x00 5.--7. 1. " I2S_MODE ,I2S Mode Select."
        textline "   "
        bitfld.long 0x00 7. " SYS_CLK_EN ,Network Clock (Oversampling Clock) Enable." "0,1"
        textline "   "
        bitfld.long 0x00 8. " TCH_EN ,Two-Channel Operation Enable." "0,1"
        textline "   "
        bitfld.long 0x00 9. " CLK_IST ,Clock Idle State." "0,1"
        textline "   "
        bitfld.long 0x00 10. " TFR_CLK_DIS ,Transmit Frame Clock Disable." "0,1"
        textline "   "
        bitfld.long 0x00 11. " RFR_CLK_DIS ,Receive Frame Clock Disable." "0,1"
        textline "   "
        bitfld.long 0x00 12. " SYNC_TX_FS ,SYNC_FS_TX bit provides a safe window for TE to be visible to the internal circuit which is just after FS occurrence." "0,1"
width 5.
group.long 0x14++0x3
    line.long 0x00 "SISR,SSI Interrupt Status Register"
        bitfld.long 0x00 0. " TFE0 ,Transmit FIFO Empty 0." "0,1"
        textline "    "
        bitfld.long 0x00 1. " TFE1 ,Transmit FIFO Empty 1." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RFF0 ,Receive FIFO Full 0." "0,1"
        textline "    "
        bitfld.long 0x00 3. " RFF1 ,Receive FIFO Full 1." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RLS ,Receive Last Time Slot." "0,1"
        textline "    "
        bitfld.long 0x00 5. " TLS ,Transmit Last Time Slot." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RFS ,Receive Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 7. " TFS ,Transmit Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 8. " TUE0 ,Transmitter Underrun Error 0." "0,1"
        textline "    "
        bitfld.long 0x00 9. " TUE1 ,Transmitter Underrun Error 1." "0,1"
        textline "    "
        bitfld.long 0x00 10. " ROE0 ,Receiver Overrun Error 0." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ROE1 ,Receiver Overrun Error 1." "0,1"
        textline "    "
        bitfld.long 0x00 12. " TDE0 ,Transmit Data Register Empty 0." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TDE1 ,Transmit Data Register Empty 1." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RDR0 ,Receive Data Ready 0." "0,1"
        textline "    "
        bitfld.long 0x00 15. " RDR1 ,Receive Data Ready 1." "0,1"
        textline "    "
        bitfld.long 0x00 16. " RXT ,Receive Tag Updated." "0,1"
        textline "    "
        bitfld.long 0x00 17. " CMDDU ,Command Data Register Updated." "0,1"
        textline "    "
        bitfld.long 0x00 18. " CMDAU ,Command Address Register Updated." "0,1"
        textline "    "
        bitfld.long 0x00 23. " TFRC ,Transmit Frame Complete." "0,1"
        textline "    "
        bitfld.long 0x00 24. " RFRC ,Receive Frame Complete." "0,1"
width 5.
group.long 0x18++0x3
    line.long 0x00 "SIER,SSI Interrupt Enable Register"
        bitfld.long 0x00 0. " TFE0IE ,Transmit FIFO Empty 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " TFE1IE ,Transmit FIFO Empty 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RFF0IE ,Receive FIFO Full 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 3. " RFF1IE ,Receive FIFO Full 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RLSIE ,Receive Last Time Slot Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " TLSIE ,Transmit Last Time Slot Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RFSIE ,Receive Frame Sync Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 7. " TFSIE ,Transmit Frame Sync Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 8. " TUE0IE ,Transmitter Underrun Error 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 9. " TUE1IE ,Transmitter Underrun Error 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 10. " ROE0IE ,Receiver Overrun Error 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ROE1IE ,Receiver Overrun Error 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 12. " TDE0IE ,Transmit Data Register Empty 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TDE1IE ,Transmit Data Register Empty 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RDR0IE ,Receive Data Ready 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 15. " RDR1IE ,Receive Data Ready 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 16. " RXTIE ,Receive Tag Updated Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 17. " CMDDUIE ,Command Data Register Updated Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 18. " CMDAUIE ,Command Address Register Updated Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 19. " TIE ,Transmit Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 20. " TDMAE ,Transmit DMA Enable." "0,1"
        textline "    "
        bitfld.long 0x00 21. " RIE ,Receive Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 22. " RDMAE ,Receive DMA Enable." "0,1"
        textline "    "
        bitfld.long 0x00 23. " TFRCIE ,Transmit Frame Complete Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 24. " RFRCIE ,Receive Frame Complete Interrupt Enable." "0,1"
width 5.
group.long 0x1c++0x3
    line.long 0x00 "STCR,SSI Transmit Configuration Register"
        bitfld.long 0x00 0. " TEFS ,Transmit Early Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 1. " TFSL ,Transmit Frame Sync Length." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TFSI ,Transmit Frame Sync Invert." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TSCKP ,Transmit Clock Polarity." "0,1"
        textline "    "
        bitfld.long 0x00 4. " TSHFD ,Transmit Shift Direction." "0,1"
        textline "    "
        bitfld.long 0x00 5. " TXDIR ,Transmit Clock Direction." "0,1"
        textline "    "
        bitfld.long 0x00 6. " TFDIR ,Transmit Frame Direction." "0,1"
        textline "    "
        bitfld.long 0x00 7. " TFEN0 ,Transmit FIFO Enable 0." "0,1"
        textline "    "
        bitfld.long 0x00 8. " TFEN1 ,Transmit FIFO Enable 1." "0,1"
        textline "    "
        bitfld.long 0x00 9. " TXBIT0 ,Transmit Bit 0." "0,1"
width 5.
group.long 0x20++0x3
    line.long 0x00 "SRCR,SSI Receive Configuration Register"
        bitfld.long 0x00 0. " REFS ,Receive Early Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RFSL ,Receive Frame Sync Length." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RFSI ,Receive Frame Sync Invert." "0,1"
        textline "    "
        bitfld.long 0x00 3. " RSCKP ,Receive Clock Polarity." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RSHFD ,Receive Shift Direction." "0,1"
        textline "    "
        bitfld.long 0x00 5. " RXDIR ,Receive Clock Direction." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RFDIR ,Receive Frame Direction." "0,1"
        textline "    "
        bitfld.long 0x00 7. " RFEN0 ,Receive FIFO Enable 0." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RFEN1 ,Receive FIFO Enable 1." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RXBIT0 ,Receive Bit 0." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RXEXT ,Receive Data Extension." "0,1"
width 6.
group.long 0x24++0x3
    line.long 0x00 "STCCR,SSI Transmit Clock Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " PM7_PM0 ,Prescaler Modulus Select."
        textline "     "
        hexmask.long.byte 0x00 8.--13. 1. " DC4_DC0 ,Frame Rate Divider Control."
        textline "     "
        hexmask.long.byte 0x00 13.--17. 1. " WL3_WL0 ,Word Length Control."
        textline "     "
        bitfld.long 0x00 17. " PSR ,Prescaler Range." "0,1"
        textline "     "
        bitfld.long 0x00 18. " DIV2 ,Divide By 2." "0,1"
width 6.
group.long 0x28++0x3
    line.long 0x00 "SRCCR,SSI Receive Clock Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " PM7_PM0 ,Prescaler Modulus Select."
        textline "     "
        hexmask.long.byte 0x00 8.--13. 1. " DC4_DC0 ,Frame Rate Divider Control."
        textline "     "
        hexmask.long.byte 0x00 13.--17. 1. " WL3_WL0 ,Word Length Control."
        textline "     "
        bitfld.long 0x00 17. " PSR ,Prescaler Range." "0,1"
        textline "     "
        bitfld.long 0x00 18. " DIV2 ,Divide By 2." "0,1"
width 6.
group.long 0x2c++0x3
    line.long 0x00 "SFCSR,SSI FIFO Control/Status Register"
        hexmask.long.byte 0x00 0.--4. 1. " TFWM0 ,Transmit FIFO Empty WaterMark 0."
        textline "     "
        hexmask.long.byte 0x00 4.--8. 1. " RFWM0 ,Receive FIFO Full WaterMark 0."
        textline "     "
        hexmask.long.byte 0x00 8.--12. 1. " TFCNT0 ,Transmit FIFO Counter 0."
        textline "     "
        hexmask.long.byte 0x00 12.--16. 1. " RFCNT0 ,Receive FIFO Counter 0."
        textline "     "
        hexmask.long.byte 0x00 16.--20. 1. " TFWM1 ,Transmit FIFO Empty WaterMark 1."
        textline "     "
        hexmask.long.byte 0x00 20.--24. 1. " RFWM1 ,Receive FIFO Full WaterMark 1."
        textline "     "
        hexmask.long.byte 0x00 24.--28. 1. " TFCNT1 ,Transmit FIFO Counter1."
        textline "     "
        hexmask.long.byte 0x00 28.--32. 1. " RFCNT1 ,Receive FIFO Counter1."
width 6.
group.long 0x38++0x3
    line.long 0x00 "SACNT,SSI AC97 Control Register"
        bitfld.long 0x00 0. " AC97EN ,AC97 Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 1. " FV ,Fixed/Variable Operation." "0,1"
        textline "     "
        bitfld.long 0x00 2. " TIF ,Tag in FIFO." "0,1"
        textline "     "
        bitfld.long 0x00 3. " RD ,Read Command." "0,1"
        textline "     "
        bitfld.long 0x00 4. " WR ,Write Command." "0,1"
        textline "     "
        hexmask.long.byte 0x00 5.--11. 1. " FRDIV ,Frame Rate Divider."
width 7.
group.long 0x3c++0x3
    line.long 0x00 "SACADD,SSI AC97 Command Address Register"
        hexmask.long.long 0x00 0.--19. 1. " SACADD ,AC97 Command Address."
width 7.
group.long 0x40++0x3
    line.long 0x00 "SACDAT,SSI AC97 Command Data Register"
        hexmask.long.long 0x00 0.--20. 1. " SACDAT ,AC97 Command Data."
width 6.
group.long 0x44++0x3
    line.long 0x00 "SATAG,SSI AC97 Tag Register"
        hexmask.long.word 0x00 0.--16. 1. " SATAG ,AC97 Tag Value."
width 6.
group.long 0x48++0x3
    line.long 0x00 "STMSK,SSI Transmit Time Slot Mask Register"
        hexmask.long.long 0x00 0.--32. 1. " STMSK ,Transmit Mask."
width 6.
group.long 0x4c++0x3
    line.long 0x00 "SRMSK,SSI Receive Time Slot Mask Register"
        hexmask.long.long 0x00 0.--32. 1. " SRMSK ,Receive Mask."
width 7.
rgroup.long 0x50++0x3
    line.long 0x00 "SACCST,SSI AC97 Channel Status Register"
        hexmask.long.word 0x00 0.--10. 1. " SACCST ,AC97 Channel Status."
width 7.
wgroup.long 0x54++0x3
    line.long 0x00 "SACCEN,SSI AC97 Channel Enable Register"
        hexmask.long.word 0x00 0.--10. 1. " SACCEN ,AC97 Channel Enable."
width 8.
wgroup.long 0x58++0x3
    line.long 0x00 "SACCDIS,SSI AC97 Channel Disable Register"
        hexmask.long.word 0x00 0.--10. 1. " SACCDIS ,AC97 Channel Disable."


    tree.end
    tree "SSI2"
        base ad:0x0202c000

width 5.
group.long 0x0++0x3
    line.long 0x00 "STX0,SSI Transmit Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " STXN ,SSI Transmit Data."
width 5.
group.long 0x4++0x3
    line.long 0x00 "STX1,SSI Transmit Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " STXN ,SSI Transmit Data."
width 5.
rgroup.long 0x8++0x3
    line.long 0x00 "SRX0,SSI Receive Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " SRXN ,SSI Receive Data."
width 5.
rgroup.long 0xc++0x3
    line.long 0x00 "SRX1,SSI Receive Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " SRXN ,SSI Receive Data."
width 4.
group.long 0x10++0x3
    line.long 0x00 "SCR,SSI Control Register"
        bitfld.long 0x00 0. " SSIEN ,SSIEN - SSI Enable This bit is used to enable/disable the SSI." "0,1"
        textline "   "
        bitfld.long 0x00 1. " TE ,Transmit Enable." "0,1"
        textline "   "
        bitfld.long 0x00 2. " RE ,Receive Enable." "0,1"
        textline "   "
        bitfld.long 0x00 3. " NET ,Network Mode." "0,1"
        textline "   "
        bitfld.long 0x00 4. " SYN ,Synchronous Mode." "0,1"
        textline "   "
        hexmask.long.byte 0x00 5.--7. 1. " I2S_MODE ,I2S Mode Select."
        textline "   "
        bitfld.long 0x00 7. " SYS_CLK_EN ,Network Clock (Oversampling Clock) Enable." "0,1"
        textline "   "
        bitfld.long 0x00 8. " TCH_EN ,Two-Channel Operation Enable." "0,1"
        textline "   "
        bitfld.long 0x00 9. " CLK_IST ,Clock Idle State." "0,1"
        textline "   "
        bitfld.long 0x00 10. " TFR_CLK_DIS ,Transmit Frame Clock Disable." "0,1"
        textline "   "
        bitfld.long 0x00 11. " RFR_CLK_DIS ,Receive Frame Clock Disable." "0,1"
        textline "   "
        bitfld.long 0x00 12. " SYNC_TX_FS ,SYNC_FS_TX bit provides a safe window for TE to be visible to the internal circuit which is just after FS occurrence." "0,1"
width 5.
group.long 0x14++0x3
    line.long 0x00 "SISR,SSI Interrupt Status Register"
        bitfld.long 0x00 0. " TFE0 ,Transmit FIFO Empty 0." "0,1"
        textline "    "
        bitfld.long 0x00 1. " TFE1 ,Transmit FIFO Empty 1." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RFF0 ,Receive FIFO Full 0." "0,1"
        textline "    "
        bitfld.long 0x00 3. " RFF1 ,Receive FIFO Full 1." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RLS ,Receive Last Time Slot." "0,1"
        textline "    "
        bitfld.long 0x00 5. " TLS ,Transmit Last Time Slot." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RFS ,Receive Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 7. " TFS ,Transmit Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 8. " TUE0 ,Transmitter Underrun Error 0." "0,1"
        textline "    "
        bitfld.long 0x00 9. " TUE1 ,Transmitter Underrun Error 1." "0,1"
        textline "    "
        bitfld.long 0x00 10. " ROE0 ,Receiver Overrun Error 0." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ROE1 ,Receiver Overrun Error 1." "0,1"
        textline "    "
        bitfld.long 0x00 12. " TDE0 ,Transmit Data Register Empty 0." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TDE1 ,Transmit Data Register Empty 1." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RDR0 ,Receive Data Ready 0." "0,1"
        textline "    "
        bitfld.long 0x00 15. " RDR1 ,Receive Data Ready 1." "0,1"
        textline "    "
        bitfld.long 0x00 16. " RXT ,Receive Tag Updated." "0,1"
        textline "    "
        bitfld.long 0x00 17. " CMDDU ,Command Data Register Updated." "0,1"
        textline "    "
        bitfld.long 0x00 18. " CMDAU ,Command Address Register Updated." "0,1"
        textline "    "
        bitfld.long 0x00 23. " TFRC ,Transmit Frame Complete." "0,1"
        textline "    "
        bitfld.long 0x00 24. " RFRC ,Receive Frame Complete." "0,1"
width 5.
group.long 0x18++0x3
    line.long 0x00 "SIER,SSI Interrupt Enable Register"
        bitfld.long 0x00 0. " TFE0IE ,Transmit FIFO Empty 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " TFE1IE ,Transmit FIFO Empty 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RFF0IE ,Receive FIFO Full 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 3. " RFF1IE ,Receive FIFO Full 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RLSIE ,Receive Last Time Slot Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " TLSIE ,Transmit Last Time Slot Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RFSIE ,Receive Frame Sync Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 7. " TFSIE ,Transmit Frame Sync Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 8. " TUE0IE ,Transmitter Underrun Error 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 9. " TUE1IE ,Transmitter Underrun Error 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 10. " ROE0IE ,Receiver Overrun Error 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ROE1IE ,Receiver Overrun Error 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 12. " TDE0IE ,Transmit Data Register Empty 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TDE1IE ,Transmit Data Register Empty 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RDR0IE ,Receive Data Ready 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 15. " RDR1IE ,Receive Data Ready 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 16. " RXTIE ,Receive Tag Updated Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 17. " CMDDUIE ,Command Data Register Updated Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 18. " CMDAUIE ,Command Address Register Updated Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 19. " TIE ,Transmit Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 20. " TDMAE ,Transmit DMA Enable." "0,1"
        textline "    "
        bitfld.long 0x00 21. " RIE ,Receive Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 22. " RDMAE ,Receive DMA Enable." "0,1"
        textline "    "
        bitfld.long 0x00 23. " TFRCIE ,Transmit Frame Complete Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 24. " RFRCIE ,Receive Frame Complete Interrupt Enable." "0,1"
width 5.
group.long 0x1c++0x3
    line.long 0x00 "STCR,SSI Transmit Configuration Register"
        bitfld.long 0x00 0. " TEFS ,Transmit Early Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 1. " TFSL ,Transmit Frame Sync Length." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TFSI ,Transmit Frame Sync Invert." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TSCKP ,Transmit Clock Polarity." "0,1"
        textline "    "
        bitfld.long 0x00 4. " TSHFD ,Transmit Shift Direction." "0,1"
        textline "    "
        bitfld.long 0x00 5. " TXDIR ,Transmit Clock Direction." "0,1"
        textline "    "
        bitfld.long 0x00 6. " TFDIR ,Transmit Frame Direction." "0,1"
        textline "    "
        bitfld.long 0x00 7. " TFEN0 ,Transmit FIFO Enable 0." "0,1"
        textline "    "
        bitfld.long 0x00 8. " TFEN1 ,Transmit FIFO Enable 1." "0,1"
        textline "    "
        bitfld.long 0x00 9. " TXBIT0 ,Transmit Bit 0." "0,1"
width 5.
group.long 0x20++0x3
    line.long 0x00 "SRCR,SSI Receive Configuration Register"
        bitfld.long 0x00 0. " REFS ,Receive Early Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RFSL ,Receive Frame Sync Length." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RFSI ,Receive Frame Sync Invert." "0,1"
        textline "    "
        bitfld.long 0x00 3. " RSCKP ,Receive Clock Polarity." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RSHFD ,Receive Shift Direction." "0,1"
        textline "    "
        bitfld.long 0x00 5. " RXDIR ,Receive Clock Direction." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RFDIR ,Receive Frame Direction." "0,1"
        textline "    "
        bitfld.long 0x00 7. " RFEN0 ,Receive FIFO Enable 0." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RFEN1 ,Receive FIFO Enable 1." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RXBIT0 ,Receive Bit 0." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RXEXT ,Receive Data Extension." "0,1"
width 6.
group.long 0x24++0x3
    line.long 0x00 "STCCR,SSI Transmit Clock Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " PM7_PM0 ,Prescaler Modulus Select."
        textline "     "
        hexmask.long.byte 0x00 8.--13. 1. " DC4_DC0 ,Frame Rate Divider Control."
        textline "     "
        hexmask.long.byte 0x00 13.--17. 1. " WL3_WL0 ,Word Length Control."
        textline "     "
        bitfld.long 0x00 17. " PSR ,Prescaler Range." "0,1"
        textline "     "
        bitfld.long 0x00 18. " DIV2 ,Divide By 2." "0,1"
width 6.
group.long 0x28++0x3
    line.long 0x00 "SRCCR,SSI Receive Clock Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " PM7_PM0 ,Prescaler Modulus Select."
        textline "     "
        hexmask.long.byte 0x00 8.--13. 1. " DC4_DC0 ,Frame Rate Divider Control."
        textline "     "
        hexmask.long.byte 0x00 13.--17. 1. " WL3_WL0 ,Word Length Control."
        textline "     "
        bitfld.long 0x00 17. " PSR ,Prescaler Range." "0,1"
        textline "     "
        bitfld.long 0x00 18. " DIV2 ,Divide By 2." "0,1"
width 6.
group.long 0x2c++0x3
    line.long 0x00 "SFCSR,SSI FIFO Control/Status Register"
        hexmask.long.byte 0x00 0.--4. 1. " TFWM0 ,Transmit FIFO Empty WaterMark 0."
        textline "     "
        hexmask.long.byte 0x00 4.--8. 1. " RFWM0 ,Receive FIFO Full WaterMark 0."
        textline "     "
        hexmask.long.byte 0x00 8.--12. 1. " TFCNT0 ,Transmit FIFO Counter 0."
        textline "     "
        hexmask.long.byte 0x00 12.--16. 1. " RFCNT0 ,Receive FIFO Counter 0."
        textline "     "
        hexmask.long.byte 0x00 16.--20. 1. " TFWM1 ,Transmit FIFO Empty WaterMark 1."
        textline "     "
        hexmask.long.byte 0x00 20.--24. 1. " RFWM1 ,Receive FIFO Full WaterMark 1."
        textline "     "
        hexmask.long.byte 0x00 24.--28. 1. " TFCNT1 ,Transmit FIFO Counter1."
        textline "     "
        hexmask.long.byte 0x00 28.--32. 1. " RFCNT1 ,Receive FIFO Counter1."
width 6.
group.long 0x38++0x3
    line.long 0x00 "SACNT,SSI AC97 Control Register"
        bitfld.long 0x00 0. " AC97EN ,AC97 Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 1. " FV ,Fixed/Variable Operation." "0,1"
        textline "     "
        bitfld.long 0x00 2. " TIF ,Tag in FIFO." "0,1"
        textline "     "
        bitfld.long 0x00 3. " RD ,Read Command." "0,1"
        textline "     "
        bitfld.long 0x00 4. " WR ,Write Command." "0,1"
        textline "     "
        hexmask.long.byte 0x00 5.--11. 1. " FRDIV ,Frame Rate Divider."
width 7.
group.long 0x3c++0x3
    line.long 0x00 "SACADD,SSI AC97 Command Address Register"
        hexmask.long.long 0x00 0.--19. 1. " SACADD ,AC97 Command Address."
width 7.
group.long 0x40++0x3
    line.long 0x00 "SACDAT,SSI AC97 Command Data Register"
        hexmask.long.long 0x00 0.--20. 1. " SACDAT ,AC97 Command Data."
width 6.
group.long 0x44++0x3
    line.long 0x00 "SATAG,SSI AC97 Tag Register"
        hexmask.long.word 0x00 0.--16. 1. " SATAG ,AC97 Tag Value."
width 6.
group.long 0x48++0x3
    line.long 0x00 "STMSK,SSI Transmit Time Slot Mask Register"
        hexmask.long.long 0x00 0.--32. 1. " STMSK ,Transmit Mask."
width 6.
group.long 0x4c++0x3
    line.long 0x00 "SRMSK,SSI Receive Time Slot Mask Register"
        hexmask.long.long 0x00 0.--32. 1. " SRMSK ,Receive Mask."
width 7.
rgroup.long 0x50++0x3
    line.long 0x00 "SACCST,SSI AC97 Channel Status Register"
        hexmask.long.word 0x00 0.--10. 1. " SACCST ,AC97 Channel Status."
width 7.
wgroup.long 0x54++0x3
    line.long 0x00 "SACCEN,SSI AC97 Channel Enable Register"
        hexmask.long.word 0x00 0.--10. 1. " SACCEN ,AC97 Channel Enable."
width 8.
wgroup.long 0x58++0x3
    line.long 0x00 "SACCDIS,SSI AC97 Channel Disable Register"
        hexmask.long.word 0x00 0.--10. 1. " SACCDIS ,AC97 Channel Disable."


    tree.end
    tree "SSI3"
        base ad:0x02030000

width 5.
group.long 0x0++0x3
    line.long 0x00 "STX0,SSI Transmit Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " STXN ,SSI Transmit Data."
width 5.
group.long 0x4++0x3
    line.long 0x00 "STX1,SSI Transmit Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " STXN ,SSI Transmit Data."
width 5.
rgroup.long 0x8++0x3
    line.long 0x00 "SRX0,SSI Receive Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " SRXN ,SSI Receive Data."
width 5.
rgroup.long 0xc++0x3
    line.long 0x00 "SRX1,SSI Receive Data Register n"
        hexmask.long.long 0x00 0.--32. 1. " SRXN ,SSI Receive Data."
width 4.
group.long 0x10++0x3
    line.long 0x00 "SCR,SSI Control Register"
        bitfld.long 0x00 0. " SSIEN ,SSIEN - SSI Enable This bit is used to enable/disable the SSI." "0,1"
        textline "   "
        bitfld.long 0x00 1. " TE ,Transmit Enable." "0,1"
        textline "   "
        bitfld.long 0x00 2. " RE ,Receive Enable." "0,1"
        textline "   "
        bitfld.long 0x00 3. " NET ,Network Mode." "0,1"
        textline "   "
        bitfld.long 0x00 4. " SYN ,Synchronous Mode." "0,1"
        textline "   "
        hexmask.long.byte 0x00 5.--7. 1. " I2S_MODE ,I2S Mode Select."
        textline "   "
        bitfld.long 0x00 7. " SYS_CLK_EN ,Network Clock (Oversampling Clock) Enable." "0,1"
        textline "   "
        bitfld.long 0x00 8. " TCH_EN ,Two-Channel Operation Enable." "0,1"
        textline "   "
        bitfld.long 0x00 9. " CLK_IST ,Clock Idle State." "0,1"
        textline "   "
        bitfld.long 0x00 10. " TFR_CLK_DIS ,Transmit Frame Clock Disable." "0,1"
        textline "   "
        bitfld.long 0x00 11. " RFR_CLK_DIS ,Receive Frame Clock Disable." "0,1"
        textline "   "
        bitfld.long 0x00 12. " SYNC_TX_FS ,SYNC_FS_TX bit provides a safe window for TE to be visible to the internal circuit which is just after FS occurrence." "0,1"
width 5.
group.long 0x14++0x3
    line.long 0x00 "SISR,SSI Interrupt Status Register"
        bitfld.long 0x00 0. " TFE0 ,Transmit FIFO Empty 0." "0,1"
        textline "    "
        bitfld.long 0x00 1. " TFE1 ,Transmit FIFO Empty 1." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RFF0 ,Receive FIFO Full 0." "0,1"
        textline "    "
        bitfld.long 0x00 3. " RFF1 ,Receive FIFO Full 1." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RLS ,Receive Last Time Slot." "0,1"
        textline "    "
        bitfld.long 0x00 5. " TLS ,Transmit Last Time Slot." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RFS ,Receive Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 7. " TFS ,Transmit Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 8. " TUE0 ,Transmitter Underrun Error 0." "0,1"
        textline "    "
        bitfld.long 0x00 9. " TUE1 ,Transmitter Underrun Error 1." "0,1"
        textline "    "
        bitfld.long 0x00 10. " ROE0 ,Receiver Overrun Error 0." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ROE1 ,Receiver Overrun Error 1." "0,1"
        textline "    "
        bitfld.long 0x00 12. " TDE0 ,Transmit Data Register Empty 0." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TDE1 ,Transmit Data Register Empty 1." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RDR0 ,Receive Data Ready 0." "0,1"
        textline "    "
        bitfld.long 0x00 15. " RDR1 ,Receive Data Ready 1." "0,1"
        textline "    "
        bitfld.long 0x00 16. " RXT ,Receive Tag Updated." "0,1"
        textline "    "
        bitfld.long 0x00 17. " CMDDU ,Command Data Register Updated." "0,1"
        textline "    "
        bitfld.long 0x00 18. " CMDAU ,Command Address Register Updated." "0,1"
        textline "    "
        bitfld.long 0x00 23. " TFRC ,Transmit Frame Complete." "0,1"
        textline "    "
        bitfld.long 0x00 24. " RFRC ,Receive Frame Complete." "0,1"
width 5.
group.long 0x18++0x3
    line.long 0x00 "SIER,SSI Interrupt Enable Register"
        bitfld.long 0x00 0. " TFE0IE ,Transmit FIFO Empty 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " TFE1IE ,Transmit FIFO Empty 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RFF0IE ,Receive FIFO Full 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 3. " RFF1IE ,Receive FIFO Full 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RLSIE ,Receive Last Time Slot Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " TLSIE ,Transmit Last Time Slot Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RFSIE ,Receive Frame Sync Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 7. " TFSIE ,Transmit Frame Sync Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 8. " TUE0IE ,Transmitter Underrun Error 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 9. " TUE1IE ,Transmitter Underrun Error 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 10. " ROE0IE ,Receiver Overrun Error 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ROE1IE ,Receiver Overrun Error 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 12. " TDE0IE ,Transmit Data Register Empty 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TDE1IE ,Transmit Data Register Empty 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RDR0IE ,Receive Data Ready 0 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 15. " RDR1IE ,Receive Data Ready 1 Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 16. " RXTIE ,Receive Tag Updated Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 17. " CMDDUIE ,Command Data Register Updated Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 18. " CMDAUIE ,Command Address Register Updated Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 19. " TIE ,Transmit Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 20. " TDMAE ,Transmit DMA Enable." "0,1"
        textline "    "
        bitfld.long 0x00 21. " RIE ,Receive Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 22. " RDMAE ,Receive DMA Enable." "0,1"
        textline "    "
        bitfld.long 0x00 23. " TFRCIE ,Transmit Frame Complete Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 24. " RFRCIE ,Receive Frame Complete Interrupt Enable." "0,1"
width 5.
group.long 0x1c++0x3
    line.long 0x00 "STCR,SSI Transmit Configuration Register"
        bitfld.long 0x00 0. " TEFS ,Transmit Early Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 1. " TFSL ,Transmit Frame Sync Length." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TFSI ,Transmit Frame Sync Invert." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TSCKP ,Transmit Clock Polarity." "0,1"
        textline "    "
        bitfld.long 0x00 4. " TSHFD ,Transmit Shift Direction." "0,1"
        textline "    "
        bitfld.long 0x00 5. " TXDIR ,Transmit Clock Direction." "0,1"
        textline "    "
        bitfld.long 0x00 6. " TFDIR ,Transmit Frame Direction." "0,1"
        textline "    "
        bitfld.long 0x00 7. " TFEN0 ,Transmit FIFO Enable 0." "0,1"
        textline "    "
        bitfld.long 0x00 8. " TFEN1 ,Transmit FIFO Enable 1." "0,1"
        textline "    "
        bitfld.long 0x00 9. " TXBIT0 ,Transmit Bit 0." "0,1"
width 5.
group.long 0x20++0x3
    line.long 0x00 "SRCR,SSI Receive Configuration Register"
        bitfld.long 0x00 0. " REFS ,Receive Early Frame Sync." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RFSL ,Receive Frame Sync Length." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RFSI ,Receive Frame Sync Invert." "0,1"
        textline "    "
        bitfld.long 0x00 3. " RSCKP ,Receive Clock Polarity." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RSHFD ,Receive Shift Direction." "0,1"
        textline "    "
        bitfld.long 0x00 5. " RXDIR ,Receive Clock Direction." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RFDIR ,Receive Frame Direction." "0,1"
        textline "    "
        bitfld.long 0x00 7. " RFEN0 ,Receive FIFO Enable 0." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RFEN1 ,Receive FIFO Enable 1." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RXBIT0 ,Receive Bit 0." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RXEXT ,Receive Data Extension." "0,1"
width 6.
group.long 0x24++0x3
    line.long 0x00 "STCCR,SSI Transmit Clock Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " PM7_PM0 ,Prescaler Modulus Select."
        textline "     "
        hexmask.long.byte 0x00 8.--13. 1. " DC4_DC0 ,Frame Rate Divider Control."
        textline "     "
        hexmask.long.byte 0x00 13.--17. 1. " WL3_WL0 ,Word Length Control."
        textline "     "
        bitfld.long 0x00 17. " PSR ,Prescaler Range." "0,1"
        textline "     "
        bitfld.long 0x00 18. " DIV2 ,Divide By 2." "0,1"
width 6.
group.long 0x28++0x3
    line.long 0x00 "SRCCR,SSI Receive Clock Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " PM7_PM0 ,Prescaler Modulus Select."
        textline "     "
        hexmask.long.byte 0x00 8.--13. 1. " DC4_DC0 ,Frame Rate Divider Control."
        textline "     "
        hexmask.long.byte 0x00 13.--17. 1. " WL3_WL0 ,Word Length Control."
        textline "     "
        bitfld.long 0x00 17. " PSR ,Prescaler Range." "0,1"
        textline "     "
        bitfld.long 0x00 18. " DIV2 ,Divide By 2." "0,1"
width 6.
group.long 0x2c++0x3
    line.long 0x00 "SFCSR,SSI FIFO Control/Status Register"
        hexmask.long.byte 0x00 0.--4. 1. " TFWM0 ,Transmit FIFO Empty WaterMark 0."
        textline "     "
        hexmask.long.byte 0x00 4.--8. 1. " RFWM0 ,Receive FIFO Full WaterMark 0."
        textline "     "
        hexmask.long.byte 0x00 8.--12. 1. " TFCNT0 ,Transmit FIFO Counter 0."
        textline "     "
        hexmask.long.byte 0x00 12.--16. 1. " RFCNT0 ,Receive FIFO Counter 0."
        textline "     "
        hexmask.long.byte 0x00 16.--20. 1. " TFWM1 ,Transmit FIFO Empty WaterMark 1."
        textline "     "
        hexmask.long.byte 0x00 20.--24. 1. " RFWM1 ,Receive FIFO Full WaterMark 1."
        textline "     "
        hexmask.long.byte 0x00 24.--28. 1. " TFCNT1 ,Transmit FIFO Counter1."
        textline "     "
        hexmask.long.byte 0x00 28.--32. 1. " RFCNT1 ,Receive FIFO Counter1."
width 6.
group.long 0x38++0x3
    line.long 0x00 "SACNT,SSI AC97 Control Register"
        bitfld.long 0x00 0. " AC97EN ,AC97 Mode Enable." "0,1"
        textline "     "
        bitfld.long 0x00 1. " FV ,Fixed/Variable Operation." "0,1"
        textline "     "
        bitfld.long 0x00 2. " TIF ,Tag in FIFO." "0,1"
        textline "     "
        bitfld.long 0x00 3. " RD ,Read Command." "0,1"
        textline "     "
        bitfld.long 0x00 4. " WR ,Write Command." "0,1"
        textline "     "
        hexmask.long.byte 0x00 5.--11. 1. " FRDIV ,Frame Rate Divider."
width 7.
group.long 0x3c++0x3
    line.long 0x00 "SACADD,SSI AC97 Command Address Register"
        hexmask.long.long 0x00 0.--19. 1. " SACADD ,AC97 Command Address."
width 7.
group.long 0x40++0x3
    line.long 0x00 "SACDAT,SSI AC97 Command Data Register"
        hexmask.long.long 0x00 0.--20. 1. " SACDAT ,AC97 Command Data."
width 6.
group.long 0x44++0x3
    line.long 0x00 "SATAG,SSI AC97 Tag Register"
        hexmask.long.word 0x00 0.--16. 1. " SATAG ,AC97 Tag Value."
width 6.
group.long 0x48++0x3
    line.long 0x00 "STMSK,SSI Transmit Time Slot Mask Register"
        hexmask.long.long 0x00 0.--32. 1. " STMSK ,Transmit Mask."
width 6.
group.long 0x4c++0x3
    line.long 0x00 "SRMSK,SSI Receive Time Slot Mask Register"
        hexmask.long.long 0x00 0.--32. 1. " SRMSK ,Receive Mask."
width 7.
rgroup.long 0x50++0x3
    line.long 0x00 "SACCST,SSI AC97 Channel Status Register"
        hexmask.long.word 0x00 0.--10. 1. " SACCST ,AC97 Channel Status."
width 7.
wgroup.long 0x54++0x3
    line.long 0x00 "SACCEN,SSI AC97 Channel Enable Register"
        hexmask.long.word 0x00 0.--10. 1. " SACCEN ,AC97 Channel Enable."
width 8.
wgroup.long 0x58++0x3
    line.long 0x00 "SACCDIS,SSI AC97 Channel Disable Register"
        hexmask.long.word 0x00 0.--10. 1. " SACCDIS ,AC97 Channel Disable."


    tree.end

tree.end



;--------------------------------------------------------------------------------
; TEMPMON
;--------------------------------------------------------------------------------
tree "TEMPMON"
    base ad:0x020c8000

width 11.
group.long 0x180++0x3
    line.long 0x00 "TEMPSENSE0,Tempsensor Control Register 0"
        bitfld.long 0x00 0. " POWER_DOWN ,This bit powers down the temperature sensor." "0,1"
        textline "          "
        bitfld.long 0x00 1. " MEASURE_TEMP ,Starts the measurement process." "0,1"
        textline "          "
        bitfld.long 0x00 2. " FINISHED ,Indicates that the latest temp is valid." "0,1"
        textline "          "
        hexmask.long.word 0x00 8.--20. 1. " TEMP_CNT ,This bit field contains the last measured temperature count."
        textline "          "
        hexmask.long.word 0x00 20.--32. 1. " ALARM_VALUE ,This bit field contains the temperature count (raw sensor output) that will generate an alarm interrupt."
width 11.
group.long 0x190++0x3
    line.long 0x00 "TEMPSENSE1,Tempsensor Control Register 1"
        hexmask.long.word 0x00 0.--16. 1. " MEASURE_FREQ ,This bits determines how many RTC clocks to wait before automatically repeating a temperature measurement."


tree.end



;--------------------------------------------------------------------------------
; UART
;--------------------------------------------------------------------------------
tree.open "UART"
    tree "UART1"
        base ad:0x02020000

width 5.
rgroup.long 0x0++0x3
    line.long 0x00 "URXD,UART Receiver Register"
        hexmask.long.byte 0x00 0.--8. 1. " RX_DATA ,Received Data ."
        textline "    "
        bitfld.long 0x00 10. " PRERR ,In RS-485 mode, it holds the ninth data bit (bit [8]) of received 9-bit RS-485 data In RS232/IrDA mode, it is the Parity Error flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " BRK ,BREAK Detect." "0,1"
        textline "    "
        bitfld.long 0x00 12. " FRMERR ,Frame Error." "0,1"
        textline "    "
        bitfld.long 0x00 13. " OVRRUN ,Receiver Overrun." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ERR ,Error Detect." "0,1"
        textline "    "
        bitfld.long 0x00 15. " CHARRDY ,Character Ready." "0,1"
width 5.
wgroup.long 0x40++0x3
    line.long 0x00 "UTXD,UART Transmitter Register"
        hexmask.long.byte 0x00 0.--8. 1. " TX_DATA ,Transmit Data ."
width 5.
group.long 0x80++0x3
    line.long 0x00 "UCR1,UART Control Register 1"
        bitfld.long 0x00 0. " UARTEN ,UART Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " DOZE ,DOZE ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " ATDMAEN ,Aging DMA Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDMAEN ,Transmitter Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " SNDBRK ,Send BREAK ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " RTSDEN ,RTS Delta Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " TXMPTYEN ,Transmitter Empty Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " IREN ,Infrared Interface Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RXDMAEN ,Receive Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDYEN ,Receiver Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--12. 1. " ICD ,Idle Condition Detect ."
        textline "    "
        bitfld.long 0x00 12. " IDEN ,Idle Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDYEN ,Transmitter Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ADBR ,Automatic Detection of Baud Rate ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADEN ,Automatic Baud Rate Detection Interrupt Enable ." "0,1"
width 5.
group.long 0x84++0x3
    line.long 0x00 "UCR2,UART Control Register 2"
        bitfld.long 0x00 0. " SRST ,Software Reset ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RXEN ,Receiver Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXEN ,Transmitter Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " ATEN ,Aging Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSEN ,Request to Send Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " WS ,Word Size ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " STPB ,Stop ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " PROE ,Parity Odd/Even ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " PREN ,Parity Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 9.--11. 1. " RTEC ,Request to Send Edge Control ."
        textline "    "
        bitfld.long 0x00 11. " ESCEN ,Escape Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " CTS ,Clear to Send ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " CTSC ,CTS Pin Control ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " IRTS ,Ignore RTS Pin ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ESCI ,Escape Sequence Interrupt Enable ." "0,1"
width 5.
group.long 0x88++0x3
    line.long 0x00 "UCR3,UART Control Register 3"
        bitfld.long 0x00 0. " ACIEN ,Autobaud Counter Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " INVT ,Invert TXD output in RS-232/RS-485 mode, set TXD active level in IrDA mode." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RXDMUXSEL ,RXD Muxed Input Selected." "0,1"
        textline "    "
        bitfld.long 0x00 3. " DTRDEN ,Data Terminal Ready Delta Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKEN ,Asynchronous WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINTEN ,Asynchronous IR WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDSEN ,Receive Status Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 7. " ADNIMP ,Autobaud Detection Not Improved-." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RI ,Ring Indicator ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " DCD ,Data Carrier Detect ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " DSR ,Data Set Ready ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " FRAERREN ,Frame Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 12. " PARERREN ,Parity Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTREN ,Data Terminal Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 14.--16. 1. " DPEC ,DTR/DSR Interrupt Edge Control ."
width 5.
group.long 0x8c++0x3
    line.long 0x00 "UCR4,UART Control Register 4"
        bitfld.long 0x00 0. " DREN ,Receive Data Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " OREN ,Receiver Overrun Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BKEN ,BREAK Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TCEN ,Transmit Complete Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " LPBYP ,Low Power Bypass ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " IRSC ,IR Special Case ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " IDDMAEN ,DMA IDLE Condition Detected Interrupt Enable Enables/Disables the receive DMA request dma_req_rx for the IDLE interrupt (triggered with IDLE flag in USR2[12])." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WKEN ,WAKE Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " ENIRI ,Serial Infrared Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " INVR ,Invert RXD input in RS-232/RS-485 Mode, d etermine RXD input logic level being sampled in In IrDA mode." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " CTSTL ,CTS Trigger Level ."
width 5.
group.long 0x90++0x3
    line.long 0x00 "UFCR,UART FIFO Control Register"
        hexmask.long.byte 0x00 0.--6. 1. " RXTL ,Receiver Trigger Level ."
        textline "    "
        bitfld.long 0x00 6. " DCEDTE ,DCE/DTE mode select ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 7.--10. 1. " RFDIV ,Reference Frequency Divider."
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " TXTL ,Transmitter Trigger Level ."
width 5.
group.long 0x94++0x3
    line.long 0x00 "USR1,UART Status Register 1"
        bitfld.long 0x00 3. " SAD ,RS-485 Slave Address Detected Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKE ,Asynchronous WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINT ,Asynchronous IR WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDS ,Receiver IDLE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 7. " DTRD ,DTR Delta." "0,1"
        textline "    "
        bitfld.long 0x00 8. " AGTIM ,Ageing Timer Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDY ,Receiver Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " FRAMERR ,Frame Error Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ESCF ,Escape Sequence Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " RTSD ,RTS Delta." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDY ,Transmitter Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RTSS ,RTS Pin Status ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " PARITYERR ,Parity Error Interrupt Flag ." "0,1"
width 5.
group.long 0x98++0x3
    line.long 0x00 "USR2,UART Status Register 2"
        bitfld.long 0x00 0. " RDR ,Receive Data Ready -Indicates that at least 1 character is received and written to the RxFIFO." "0,1"
        textline "    "
        bitfld.long 0x00 1. " ORE ,Overrun Error ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BRCD ,BREAK Condition Detected ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDC ,Transmitter Complete ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSF ,RTS Edge Triggered Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " DCDIN ,Data Carrier Detect Input ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " DCDDELT ,Data Carrier Detect Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WAKE ,Wake ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " IRINT ,Serial Infrared Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RIIN ,Ring Indicator Input ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RIDELT ,Ring Indicator Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ACST ,Autobaud Counter Stopped ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " IDLE ,Idle Condition ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTRF ,DTR edge triggered interrupt flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " TXFE ,Transmit Buffer FIFO Empty ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADET ,Automatic Baud Rate Detect Complete ." "0,1"
width 5.
group.long 0x9c++0x3
    line.long 0x00 "UESC,UART Escape Character Register"
        hexmask.long.byte 0x00 0.--8. 1. " ESC_CHAR ,UART Escape Character ."
width 5.
group.long 0xa0++0x3
    line.long 0x00 "UTIM,UART Escape Timer Register"
        hexmask.long.word 0x00 0.--12. 1. " TIM ,UART Escape Timer."
width 5.
group.long 0xa4++0x3
    line.long 0x00 "UBIR,UART BRM Incremental Register"
        hexmask.long.word 0x00 0.--16. 1. " INC ,Incremental Numerator."
width 5.
group.long 0xa8++0x3
    line.long 0x00 "UBMR,UART BRM Modulator Register"
        hexmask.long.word 0x00 0.--16. 1. " MOD ,Modulator Denominator."
width 5.
rgroup.long 0xac++0x3
    line.long 0x00 "UBRC,UART Baud Rate Count Register"
        hexmask.long.word 0x00 0.--16. 1. " BCNT ,Baud Rate Count Register."
width 6.
group.long 0xb0++0x3
    line.long 0x00 "ONEMS,UART One Millisecond Register"
        hexmask.long.long 0x00 0.--24. 1. " ONEMS ,One Millisecond Register."
width 4.
group.long 0xb4++0x3
    line.long 0x00 "UTS,UART Test Register"
        bitfld.long 0x00 0. " SOFTRST ,Software Reset." "0,1"
        textline "   "
        bitfld.long 0x00 3. " RXFULL ,RxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 4. " TXFULL ,TxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 5. " RXEMPTY ,RxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 6. " TXEMPTY ,TxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 9. " RXDBG ,RX_fifo_debug_mode." "0,1"
        textline "   "
        bitfld.long 0x00 10. " LOOPIR ,Loop TX and RX for IR Test (LOOPIR) ." "0,1"
        textline "   "
        bitfld.long 0x00 11. " DBGEN ,debug_enable ." "0,1"
        textline "   "
        bitfld.long 0x00 12. " LOOP ,Loop TX and RX for Test." "0,1"
        textline "   "
        bitfld.long 0x00 13. " FRCPERR ,Force Parity Error." "0,1"
width 5.
group.long 0xb8++0x3
    line.long 0x00 "UMCR,UART RS-485 Mode Control Register"
        bitfld.long 0x00 0. " MDEN ,9-bit data or Multidrop Mode (RS-485) Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " SLAM ,RS-485 Slave Address Detect Mode Selection." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXB8 ,Transmit RS-485 bit 8 (the ninth bit or 9 th bit)." "0,1"
        textline "    "
        bitfld.long 0x00 3. " SADEN ,RS-485 Slave Address Detected Interrupt Enable." "0,1"
        textline "    "
        hexmask.long.byte 0x00 8.--16. 1. " SLADDR ,RS-485 Slave Address Character."


    tree.end
    tree "UART2"
        base ad:0x02024000

width 5.
rgroup.long 0x0++0x3
    line.long 0x00 "URXD,UART Receiver Register"
        hexmask.long.byte 0x00 0.--8. 1. " RX_DATA ,Received Data ."
        textline "    "
        bitfld.long 0x00 10. " PRERR ,In RS-485 mode, it holds the ninth data bit (bit [8]) of received 9-bit RS-485 data In RS232/IrDA mode, it is the Parity Error flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " BRK ,BREAK Detect." "0,1"
        textline "    "
        bitfld.long 0x00 12. " FRMERR ,Frame Error." "0,1"
        textline "    "
        bitfld.long 0x00 13. " OVRRUN ,Receiver Overrun." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ERR ,Error Detect." "0,1"
        textline "    "
        bitfld.long 0x00 15. " CHARRDY ,Character Ready." "0,1"
width 5.
wgroup.long 0x40++0x3
    line.long 0x00 "UTXD,UART Transmitter Register"
        hexmask.long.byte 0x00 0.--8. 1. " TX_DATA ,Transmit Data ."
width 5.
group.long 0x80++0x3
    line.long 0x00 "UCR1,UART Control Register 1"
        bitfld.long 0x00 0. " UARTEN ,UART Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " DOZE ,DOZE ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " ATDMAEN ,Aging DMA Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDMAEN ,Transmitter Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " SNDBRK ,Send BREAK ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " RTSDEN ,RTS Delta Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " TXMPTYEN ,Transmitter Empty Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " IREN ,Infrared Interface Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RXDMAEN ,Receive Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDYEN ,Receiver Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--12. 1. " ICD ,Idle Condition Detect ."
        textline "    "
        bitfld.long 0x00 12. " IDEN ,Idle Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDYEN ,Transmitter Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ADBR ,Automatic Detection of Baud Rate ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADEN ,Automatic Baud Rate Detection Interrupt Enable ." "0,1"
width 5.
group.long 0x84++0x3
    line.long 0x00 "UCR2,UART Control Register 2"
        bitfld.long 0x00 0. " SRST ,Software Reset ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RXEN ,Receiver Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXEN ,Transmitter Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " ATEN ,Aging Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSEN ,Request to Send Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " WS ,Word Size ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " STPB ,Stop ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " PROE ,Parity Odd/Even ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " PREN ,Parity Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 9.--11. 1. " RTEC ,Request to Send Edge Control ."
        textline "    "
        bitfld.long 0x00 11. " ESCEN ,Escape Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " CTS ,Clear to Send ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " CTSC ,CTS Pin Control ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " IRTS ,Ignore RTS Pin ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ESCI ,Escape Sequence Interrupt Enable ." "0,1"
width 5.
group.long 0x88++0x3
    line.long 0x00 "UCR3,UART Control Register 3"
        bitfld.long 0x00 0. " ACIEN ,Autobaud Counter Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " INVT ,Invert TXD output in RS-232/RS-485 mode, set TXD active level in IrDA mode." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RXDMUXSEL ,RXD Muxed Input Selected." "0,1"
        textline "    "
        bitfld.long 0x00 3. " DTRDEN ,Data Terminal Ready Delta Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKEN ,Asynchronous WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINTEN ,Asynchronous IR WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDSEN ,Receive Status Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 7. " ADNIMP ,Autobaud Detection Not Improved-." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RI ,Ring Indicator ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " DCD ,Data Carrier Detect ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " DSR ,Data Set Ready ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " FRAERREN ,Frame Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 12. " PARERREN ,Parity Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTREN ,Data Terminal Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 14.--16. 1. " DPEC ,DTR/DSR Interrupt Edge Control ."
width 5.
group.long 0x8c++0x3
    line.long 0x00 "UCR4,UART Control Register 4"
        bitfld.long 0x00 0. " DREN ,Receive Data Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " OREN ,Receiver Overrun Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BKEN ,BREAK Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TCEN ,Transmit Complete Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " LPBYP ,Low Power Bypass ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " IRSC ,IR Special Case ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " IDDMAEN ,DMA IDLE Condition Detected Interrupt Enable Enables/Disables the receive DMA request dma_req_rx for the IDLE interrupt (triggered with IDLE flag in USR2[12])." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WKEN ,WAKE Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " ENIRI ,Serial Infrared Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " INVR ,Invert RXD input in RS-232/RS-485 Mode, d etermine RXD input logic level being sampled in In IrDA mode." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " CTSTL ,CTS Trigger Level ."
width 5.
group.long 0x90++0x3
    line.long 0x00 "UFCR,UART FIFO Control Register"
        hexmask.long.byte 0x00 0.--6. 1. " RXTL ,Receiver Trigger Level ."
        textline "    "
        bitfld.long 0x00 6. " DCEDTE ,DCE/DTE mode select ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 7.--10. 1. " RFDIV ,Reference Frequency Divider."
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " TXTL ,Transmitter Trigger Level ."
width 5.
group.long 0x94++0x3
    line.long 0x00 "USR1,UART Status Register 1"
        bitfld.long 0x00 3. " SAD ,RS-485 Slave Address Detected Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKE ,Asynchronous WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINT ,Asynchronous IR WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDS ,Receiver IDLE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 7. " DTRD ,DTR Delta." "0,1"
        textline "    "
        bitfld.long 0x00 8. " AGTIM ,Ageing Timer Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDY ,Receiver Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " FRAMERR ,Frame Error Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ESCF ,Escape Sequence Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " RTSD ,RTS Delta." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDY ,Transmitter Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RTSS ,RTS Pin Status ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " PARITYERR ,Parity Error Interrupt Flag ." "0,1"
width 5.
group.long 0x98++0x3
    line.long 0x00 "USR2,UART Status Register 2"
        bitfld.long 0x00 0. " RDR ,Receive Data Ready -Indicates that at least 1 character is received and written to the RxFIFO." "0,1"
        textline "    "
        bitfld.long 0x00 1. " ORE ,Overrun Error ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BRCD ,BREAK Condition Detected ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDC ,Transmitter Complete ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSF ,RTS Edge Triggered Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " DCDIN ,Data Carrier Detect Input ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " DCDDELT ,Data Carrier Detect Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WAKE ,Wake ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " IRINT ,Serial Infrared Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RIIN ,Ring Indicator Input ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RIDELT ,Ring Indicator Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ACST ,Autobaud Counter Stopped ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " IDLE ,Idle Condition ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTRF ,DTR edge triggered interrupt flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " TXFE ,Transmit Buffer FIFO Empty ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADET ,Automatic Baud Rate Detect Complete ." "0,1"
width 5.
group.long 0x9c++0x3
    line.long 0x00 "UESC,UART Escape Character Register"
        hexmask.long.byte 0x00 0.--8. 1. " ESC_CHAR ,UART Escape Character ."
width 5.
group.long 0xa0++0x3
    line.long 0x00 "UTIM,UART Escape Timer Register"
        hexmask.long.word 0x00 0.--12. 1. " TIM ,UART Escape Timer."
width 5.
group.long 0xa4++0x3
    line.long 0x00 "UBIR,UART BRM Incremental Register"
        hexmask.long.word 0x00 0.--16. 1. " INC ,Incremental Numerator."
width 5.
group.long 0xa8++0x3
    line.long 0x00 "UBMR,UART BRM Modulator Register"
        hexmask.long.word 0x00 0.--16. 1. " MOD ,Modulator Denominator."
width 5.
rgroup.long 0xac++0x3
    line.long 0x00 "UBRC,UART Baud Rate Count Register"
        hexmask.long.word 0x00 0.--16. 1. " BCNT ,Baud Rate Count Register."
width 6.
group.long 0xb0++0x3
    line.long 0x00 "ONEMS,UART One Millisecond Register"
        hexmask.long.long 0x00 0.--24. 1. " ONEMS ,One Millisecond Register."
width 4.
group.long 0xb4++0x3
    line.long 0x00 "UTS,UART Test Register"
        bitfld.long 0x00 0. " SOFTRST ,Software Reset." "0,1"
        textline "   "
        bitfld.long 0x00 3. " RXFULL ,RxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 4. " TXFULL ,TxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 5. " RXEMPTY ,RxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 6. " TXEMPTY ,TxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 9. " RXDBG ,RX_fifo_debug_mode." "0,1"
        textline "   "
        bitfld.long 0x00 10. " LOOPIR ,Loop TX and RX for IR Test (LOOPIR) ." "0,1"
        textline "   "
        bitfld.long 0x00 11. " DBGEN ,debug_enable ." "0,1"
        textline "   "
        bitfld.long 0x00 12. " LOOP ,Loop TX and RX for Test." "0,1"
        textline "   "
        bitfld.long 0x00 13. " FRCPERR ,Force Parity Error." "0,1"
width 5.
group.long 0xb8++0x3
    line.long 0x00 "UMCR,UART RS-485 Mode Control Register"
        bitfld.long 0x00 0. " MDEN ,9-bit data or Multidrop Mode (RS-485) Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " SLAM ,RS-485 Slave Address Detect Mode Selection." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXB8 ,Transmit RS-485 bit 8 (the ninth bit or 9 th bit)." "0,1"
        textline "    "
        bitfld.long 0x00 3. " SADEN ,RS-485 Slave Address Detected Interrupt Enable." "0,1"
        textline "    "
        hexmask.long.byte 0x00 8.--16. 1. " SLADDR ,RS-485 Slave Address Character."


    tree.end
    tree "UART3"
        base ad:0x02034000

width 5.
rgroup.long 0x0++0x3
    line.long 0x00 "URXD,UART Receiver Register"
        hexmask.long.byte 0x00 0.--8. 1. " RX_DATA ,Received Data ."
        textline "    "
        bitfld.long 0x00 10. " PRERR ,In RS-485 mode, it holds the ninth data bit (bit [8]) of received 9-bit RS-485 data In RS232/IrDA mode, it is the Parity Error flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " BRK ,BREAK Detect." "0,1"
        textline "    "
        bitfld.long 0x00 12. " FRMERR ,Frame Error." "0,1"
        textline "    "
        bitfld.long 0x00 13. " OVRRUN ,Receiver Overrun." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ERR ,Error Detect." "0,1"
        textline "    "
        bitfld.long 0x00 15. " CHARRDY ,Character Ready." "0,1"
width 5.
wgroup.long 0x40++0x3
    line.long 0x00 "UTXD,UART Transmitter Register"
        hexmask.long.byte 0x00 0.--8. 1. " TX_DATA ,Transmit Data ."
width 5.
group.long 0x80++0x3
    line.long 0x00 "UCR1,UART Control Register 1"
        bitfld.long 0x00 0. " UARTEN ,UART Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " DOZE ,DOZE ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " ATDMAEN ,Aging DMA Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDMAEN ,Transmitter Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " SNDBRK ,Send BREAK ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " RTSDEN ,RTS Delta Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " TXMPTYEN ,Transmitter Empty Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " IREN ,Infrared Interface Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RXDMAEN ,Receive Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDYEN ,Receiver Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--12. 1. " ICD ,Idle Condition Detect ."
        textline "    "
        bitfld.long 0x00 12. " IDEN ,Idle Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDYEN ,Transmitter Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ADBR ,Automatic Detection of Baud Rate ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADEN ,Automatic Baud Rate Detection Interrupt Enable ." "0,1"
width 5.
group.long 0x84++0x3
    line.long 0x00 "UCR2,UART Control Register 2"
        bitfld.long 0x00 0. " SRST ,Software Reset ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RXEN ,Receiver Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXEN ,Transmitter Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " ATEN ,Aging Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSEN ,Request to Send Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " WS ,Word Size ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " STPB ,Stop ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " PROE ,Parity Odd/Even ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " PREN ,Parity Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 9.--11. 1. " RTEC ,Request to Send Edge Control ."
        textline "    "
        bitfld.long 0x00 11. " ESCEN ,Escape Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " CTS ,Clear to Send ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " CTSC ,CTS Pin Control ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " IRTS ,Ignore RTS Pin ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ESCI ,Escape Sequence Interrupt Enable ." "0,1"
width 5.
group.long 0x88++0x3
    line.long 0x00 "UCR3,UART Control Register 3"
        bitfld.long 0x00 0. " ACIEN ,Autobaud Counter Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " INVT ,Invert TXD output in RS-232/RS-485 mode, set TXD active level in IrDA mode." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RXDMUXSEL ,RXD Muxed Input Selected." "0,1"
        textline "    "
        bitfld.long 0x00 3. " DTRDEN ,Data Terminal Ready Delta Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKEN ,Asynchronous WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINTEN ,Asynchronous IR WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDSEN ,Receive Status Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 7. " ADNIMP ,Autobaud Detection Not Improved-." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RI ,Ring Indicator ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " DCD ,Data Carrier Detect ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " DSR ,Data Set Ready ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " FRAERREN ,Frame Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 12. " PARERREN ,Parity Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTREN ,Data Terminal Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 14.--16. 1. " DPEC ,DTR/DSR Interrupt Edge Control ."
width 5.
group.long 0x8c++0x3
    line.long 0x00 "UCR4,UART Control Register 4"
        bitfld.long 0x00 0. " DREN ,Receive Data Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " OREN ,Receiver Overrun Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BKEN ,BREAK Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TCEN ,Transmit Complete Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " LPBYP ,Low Power Bypass ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " IRSC ,IR Special Case ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " IDDMAEN ,DMA IDLE Condition Detected Interrupt Enable Enables/Disables the receive DMA request dma_req_rx for the IDLE interrupt (triggered with IDLE flag in USR2[12])." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WKEN ,WAKE Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " ENIRI ,Serial Infrared Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " INVR ,Invert RXD input in RS-232/RS-485 Mode, d etermine RXD input logic level being sampled in In IrDA mode." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " CTSTL ,CTS Trigger Level ."
width 5.
group.long 0x90++0x3
    line.long 0x00 "UFCR,UART FIFO Control Register"
        hexmask.long.byte 0x00 0.--6. 1. " RXTL ,Receiver Trigger Level ."
        textline "    "
        bitfld.long 0x00 6. " DCEDTE ,DCE/DTE mode select ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 7.--10. 1. " RFDIV ,Reference Frequency Divider."
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " TXTL ,Transmitter Trigger Level ."
width 5.
group.long 0x94++0x3
    line.long 0x00 "USR1,UART Status Register 1"
        bitfld.long 0x00 3. " SAD ,RS-485 Slave Address Detected Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKE ,Asynchronous WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINT ,Asynchronous IR WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDS ,Receiver IDLE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 7. " DTRD ,DTR Delta." "0,1"
        textline "    "
        bitfld.long 0x00 8. " AGTIM ,Ageing Timer Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDY ,Receiver Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " FRAMERR ,Frame Error Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ESCF ,Escape Sequence Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " RTSD ,RTS Delta." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDY ,Transmitter Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RTSS ,RTS Pin Status ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " PARITYERR ,Parity Error Interrupt Flag ." "0,1"
width 5.
group.long 0x98++0x3
    line.long 0x00 "USR2,UART Status Register 2"
        bitfld.long 0x00 0. " RDR ,Receive Data Ready -Indicates that at least 1 character is received and written to the RxFIFO." "0,1"
        textline "    "
        bitfld.long 0x00 1. " ORE ,Overrun Error ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BRCD ,BREAK Condition Detected ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDC ,Transmitter Complete ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSF ,RTS Edge Triggered Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " DCDIN ,Data Carrier Detect Input ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " DCDDELT ,Data Carrier Detect Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WAKE ,Wake ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " IRINT ,Serial Infrared Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RIIN ,Ring Indicator Input ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RIDELT ,Ring Indicator Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ACST ,Autobaud Counter Stopped ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " IDLE ,Idle Condition ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTRF ,DTR edge triggered interrupt flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " TXFE ,Transmit Buffer FIFO Empty ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADET ,Automatic Baud Rate Detect Complete ." "0,1"
width 5.
group.long 0x9c++0x3
    line.long 0x00 "UESC,UART Escape Character Register"
        hexmask.long.byte 0x00 0.--8. 1. " ESC_CHAR ,UART Escape Character ."
width 5.
group.long 0xa0++0x3
    line.long 0x00 "UTIM,UART Escape Timer Register"
        hexmask.long.word 0x00 0.--12. 1. " TIM ,UART Escape Timer."
width 5.
group.long 0xa4++0x3
    line.long 0x00 "UBIR,UART BRM Incremental Register"
        hexmask.long.word 0x00 0.--16. 1. " INC ,Incremental Numerator."
width 5.
group.long 0xa8++0x3
    line.long 0x00 "UBMR,UART BRM Modulator Register"
        hexmask.long.word 0x00 0.--16. 1. " MOD ,Modulator Denominator."
width 5.
rgroup.long 0xac++0x3
    line.long 0x00 "UBRC,UART Baud Rate Count Register"
        hexmask.long.word 0x00 0.--16. 1. " BCNT ,Baud Rate Count Register."
width 6.
group.long 0xb0++0x3
    line.long 0x00 "ONEMS,UART One Millisecond Register"
        hexmask.long.long 0x00 0.--24. 1. " ONEMS ,One Millisecond Register."
width 4.
group.long 0xb4++0x3
    line.long 0x00 "UTS,UART Test Register"
        bitfld.long 0x00 0. " SOFTRST ,Software Reset." "0,1"
        textline "   "
        bitfld.long 0x00 3. " RXFULL ,RxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 4. " TXFULL ,TxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 5. " RXEMPTY ,RxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 6. " TXEMPTY ,TxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 9. " RXDBG ,RX_fifo_debug_mode." "0,1"
        textline "   "
        bitfld.long 0x00 10. " LOOPIR ,Loop TX and RX for IR Test (LOOPIR) ." "0,1"
        textline "   "
        bitfld.long 0x00 11. " DBGEN ,debug_enable ." "0,1"
        textline "   "
        bitfld.long 0x00 12. " LOOP ,Loop TX and RX for Test." "0,1"
        textline "   "
        bitfld.long 0x00 13. " FRCPERR ,Force Parity Error." "0,1"
width 5.
group.long 0xb8++0x3
    line.long 0x00 "UMCR,UART RS-485 Mode Control Register"
        bitfld.long 0x00 0. " MDEN ,9-bit data or Multidrop Mode (RS-485) Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " SLAM ,RS-485 Slave Address Detect Mode Selection." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXB8 ,Transmit RS-485 bit 8 (the ninth bit or 9 th bit)." "0,1"
        textline "    "
        bitfld.long 0x00 3. " SADEN ,RS-485 Slave Address Detected Interrupt Enable." "0,1"
        textline "    "
        hexmask.long.byte 0x00 8.--16. 1. " SLADDR ,RS-485 Slave Address Character."


    tree.end
    tree "UART4"
        base ad:0x02038000

width 5.
rgroup.long 0x0++0x3
    line.long 0x00 "URXD,UART Receiver Register"
        hexmask.long.byte 0x00 0.--8. 1. " RX_DATA ,Received Data ."
        textline "    "
        bitfld.long 0x00 10. " PRERR ,In RS-485 mode, it holds the ninth data bit (bit [8]) of received 9-bit RS-485 data In RS232/IrDA mode, it is the Parity Error flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " BRK ,BREAK Detect." "0,1"
        textline "    "
        bitfld.long 0x00 12. " FRMERR ,Frame Error." "0,1"
        textline "    "
        bitfld.long 0x00 13. " OVRRUN ,Receiver Overrun." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ERR ,Error Detect." "0,1"
        textline "    "
        bitfld.long 0x00 15. " CHARRDY ,Character Ready." "0,1"
width 5.
wgroup.long 0x40++0x3
    line.long 0x00 "UTXD,UART Transmitter Register"
        hexmask.long.byte 0x00 0.--8. 1. " TX_DATA ,Transmit Data ."
width 5.
group.long 0x80++0x3
    line.long 0x00 "UCR1,UART Control Register 1"
        bitfld.long 0x00 0. " UARTEN ,UART Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " DOZE ,DOZE ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " ATDMAEN ,Aging DMA Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDMAEN ,Transmitter Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " SNDBRK ,Send BREAK ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " RTSDEN ,RTS Delta Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " TXMPTYEN ,Transmitter Empty Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " IREN ,Infrared Interface Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RXDMAEN ,Receive Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDYEN ,Receiver Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--12. 1. " ICD ,Idle Condition Detect ."
        textline "    "
        bitfld.long 0x00 12. " IDEN ,Idle Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDYEN ,Transmitter Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ADBR ,Automatic Detection of Baud Rate ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADEN ,Automatic Baud Rate Detection Interrupt Enable ." "0,1"
width 5.
group.long 0x84++0x3
    line.long 0x00 "UCR2,UART Control Register 2"
        bitfld.long 0x00 0. " SRST ,Software Reset ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RXEN ,Receiver Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXEN ,Transmitter Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " ATEN ,Aging Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSEN ,Request to Send Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " WS ,Word Size ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " STPB ,Stop ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " PROE ,Parity Odd/Even ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " PREN ,Parity Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 9.--11. 1. " RTEC ,Request to Send Edge Control ."
        textline "    "
        bitfld.long 0x00 11. " ESCEN ,Escape Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " CTS ,Clear to Send ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " CTSC ,CTS Pin Control ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " IRTS ,Ignore RTS Pin ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ESCI ,Escape Sequence Interrupt Enable ." "0,1"
width 5.
group.long 0x88++0x3
    line.long 0x00 "UCR3,UART Control Register 3"
        bitfld.long 0x00 0. " ACIEN ,Autobaud Counter Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " INVT ,Invert TXD output in RS-232/RS-485 mode, set TXD active level in IrDA mode." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RXDMUXSEL ,RXD Muxed Input Selected." "0,1"
        textline "    "
        bitfld.long 0x00 3. " DTRDEN ,Data Terminal Ready Delta Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKEN ,Asynchronous WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINTEN ,Asynchronous IR WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDSEN ,Receive Status Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 7. " ADNIMP ,Autobaud Detection Not Improved-." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RI ,Ring Indicator ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " DCD ,Data Carrier Detect ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " DSR ,Data Set Ready ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " FRAERREN ,Frame Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 12. " PARERREN ,Parity Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTREN ,Data Terminal Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 14.--16. 1. " DPEC ,DTR/DSR Interrupt Edge Control ."
width 5.
group.long 0x8c++0x3
    line.long 0x00 "UCR4,UART Control Register 4"
        bitfld.long 0x00 0. " DREN ,Receive Data Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " OREN ,Receiver Overrun Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BKEN ,BREAK Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TCEN ,Transmit Complete Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " LPBYP ,Low Power Bypass ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " IRSC ,IR Special Case ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " IDDMAEN ,DMA IDLE Condition Detected Interrupt Enable Enables/Disables the receive DMA request dma_req_rx for the IDLE interrupt (triggered with IDLE flag in USR2[12])." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WKEN ,WAKE Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " ENIRI ,Serial Infrared Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " INVR ,Invert RXD input in RS-232/RS-485 Mode, d etermine RXD input logic level being sampled in In IrDA mode." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " CTSTL ,CTS Trigger Level ."
width 5.
group.long 0x90++0x3
    line.long 0x00 "UFCR,UART FIFO Control Register"
        hexmask.long.byte 0x00 0.--6. 1. " RXTL ,Receiver Trigger Level ."
        textline "    "
        bitfld.long 0x00 6. " DCEDTE ,DCE/DTE mode select ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 7.--10. 1. " RFDIV ,Reference Frequency Divider."
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " TXTL ,Transmitter Trigger Level ."
width 5.
group.long 0x94++0x3
    line.long 0x00 "USR1,UART Status Register 1"
        bitfld.long 0x00 3. " SAD ,RS-485 Slave Address Detected Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKE ,Asynchronous WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINT ,Asynchronous IR WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDS ,Receiver IDLE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 7. " DTRD ,DTR Delta." "0,1"
        textline "    "
        bitfld.long 0x00 8. " AGTIM ,Ageing Timer Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDY ,Receiver Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " FRAMERR ,Frame Error Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ESCF ,Escape Sequence Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " RTSD ,RTS Delta." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDY ,Transmitter Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RTSS ,RTS Pin Status ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " PARITYERR ,Parity Error Interrupt Flag ." "0,1"
width 5.
group.long 0x98++0x3
    line.long 0x00 "USR2,UART Status Register 2"
        bitfld.long 0x00 0. " RDR ,Receive Data Ready -Indicates that at least 1 character is received and written to the RxFIFO." "0,1"
        textline "    "
        bitfld.long 0x00 1. " ORE ,Overrun Error ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BRCD ,BREAK Condition Detected ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDC ,Transmitter Complete ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSF ,RTS Edge Triggered Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " DCDIN ,Data Carrier Detect Input ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " DCDDELT ,Data Carrier Detect Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WAKE ,Wake ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " IRINT ,Serial Infrared Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RIIN ,Ring Indicator Input ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RIDELT ,Ring Indicator Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ACST ,Autobaud Counter Stopped ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " IDLE ,Idle Condition ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTRF ,DTR edge triggered interrupt flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " TXFE ,Transmit Buffer FIFO Empty ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADET ,Automatic Baud Rate Detect Complete ." "0,1"
width 5.
group.long 0x9c++0x3
    line.long 0x00 "UESC,UART Escape Character Register"
        hexmask.long.byte 0x00 0.--8. 1. " ESC_CHAR ,UART Escape Character ."
width 5.
group.long 0xa0++0x3
    line.long 0x00 "UTIM,UART Escape Timer Register"
        hexmask.long.word 0x00 0.--12. 1. " TIM ,UART Escape Timer."
width 5.
group.long 0xa4++0x3
    line.long 0x00 "UBIR,UART BRM Incremental Register"
        hexmask.long.word 0x00 0.--16. 1. " INC ,Incremental Numerator."
width 5.
group.long 0xa8++0x3
    line.long 0x00 "UBMR,UART BRM Modulator Register"
        hexmask.long.word 0x00 0.--16. 1. " MOD ,Modulator Denominator."
width 5.
rgroup.long 0xac++0x3
    line.long 0x00 "UBRC,UART Baud Rate Count Register"
        hexmask.long.word 0x00 0.--16. 1. " BCNT ,Baud Rate Count Register."
width 6.
group.long 0xb0++0x3
    line.long 0x00 "ONEMS,UART One Millisecond Register"
        hexmask.long.long 0x00 0.--24. 1. " ONEMS ,One Millisecond Register."
width 4.
group.long 0xb4++0x3
    line.long 0x00 "UTS,UART Test Register"
        bitfld.long 0x00 0. " SOFTRST ,Software Reset." "0,1"
        textline "   "
        bitfld.long 0x00 3. " RXFULL ,RxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 4. " TXFULL ,TxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 5. " RXEMPTY ,RxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 6. " TXEMPTY ,TxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 9. " RXDBG ,RX_fifo_debug_mode." "0,1"
        textline "   "
        bitfld.long 0x00 10. " LOOPIR ,Loop TX and RX for IR Test (LOOPIR) ." "0,1"
        textline "   "
        bitfld.long 0x00 11. " DBGEN ,debug_enable ." "0,1"
        textline "   "
        bitfld.long 0x00 12. " LOOP ,Loop TX and RX for Test." "0,1"
        textline "   "
        bitfld.long 0x00 13. " FRCPERR ,Force Parity Error." "0,1"
width 5.
group.long 0xb8++0x3
    line.long 0x00 "UMCR,UART RS-485 Mode Control Register"
        bitfld.long 0x00 0. " MDEN ,9-bit data or Multidrop Mode (RS-485) Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " SLAM ,RS-485 Slave Address Detect Mode Selection." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXB8 ,Transmit RS-485 bit 8 (the ninth bit or 9 th bit)." "0,1"
        textline "    "
        bitfld.long 0x00 3. " SADEN ,RS-485 Slave Address Detected Interrupt Enable." "0,1"
        textline "    "
        hexmask.long.byte 0x00 8.--16. 1. " SLADDR ,RS-485 Slave Address Character."


    tree.end
    tree "UART5"
        base ad:0x02018000

width 5.
rgroup.long 0x0++0x3
    line.long 0x00 "URXD,UART Receiver Register"
        hexmask.long.byte 0x00 0.--8. 1. " RX_DATA ,Received Data ."
        textline "    "
        bitfld.long 0x00 10. " PRERR ,In RS-485 mode, it holds the ninth data bit (bit [8]) of received 9-bit RS-485 data In RS232/IrDA mode, it is the Parity Error flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " BRK ,BREAK Detect." "0,1"
        textline "    "
        bitfld.long 0x00 12. " FRMERR ,Frame Error." "0,1"
        textline "    "
        bitfld.long 0x00 13. " OVRRUN ,Receiver Overrun." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ERR ,Error Detect." "0,1"
        textline "    "
        bitfld.long 0x00 15. " CHARRDY ,Character Ready." "0,1"
width 5.
wgroup.long 0x40++0x3
    line.long 0x00 "UTXD,UART Transmitter Register"
        hexmask.long.byte 0x00 0.--8. 1. " TX_DATA ,Transmit Data ."
width 5.
group.long 0x80++0x3
    line.long 0x00 "UCR1,UART Control Register 1"
        bitfld.long 0x00 0. " UARTEN ,UART Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " DOZE ,DOZE ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " ATDMAEN ,Aging DMA Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDMAEN ,Transmitter Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " SNDBRK ,Send BREAK ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " RTSDEN ,RTS Delta Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " TXMPTYEN ,Transmitter Empty Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " IREN ,Infrared Interface Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RXDMAEN ,Receive Ready DMA Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDYEN ,Receiver Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--12. 1. " ICD ,Idle Condition Detect ."
        textline "    "
        bitfld.long 0x00 12. " IDEN ,Idle Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDYEN ,Transmitter Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ADBR ,Automatic Detection of Baud Rate ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADEN ,Automatic Baud Rate Detection Interrupt Enable ." "0,1"
width 5.
group.long 0x84++0x3
    line.long 0x00 "UCR2,UART Control Register 2"
        bitfld.long 0x00 0. " SRST ,Software Reset ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " RXEN ,Receiver Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXEN ,Transmitter Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " ATEN ,Aging Timer Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSEN ,Request to Send Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " WS ,Word Size ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " STPB ,Stop ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " PROE ,Parity Odd/Even ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " PREN ,Parity Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 9.--11. 1. " RTEC ,Request to Send Edge Control ."
        textline "    "
        bitfld.long 0x00 11. " ESCEN ,Escape Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " CTS ,Clear to Send ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " CTSC ,CTS Pin Control ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " IRTS ,Ignore RTS Pin ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ESCI ,Escape Sequence Interrupt Enable ." "0,1"
width 5.
group.long 0x88++0x3
    line.long 0x00 "UCR3,UART Control Register 3"
        bitfld.long 0x00 0. " ACIEN ,Autobaud Counter Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " INVT ,Invert TXD output in RS-232/RS-485 mode, set TXD active level in IrDA mode." "0,1"
        textline "    "
        bitfld.long 0x00 2. " RXDMUXSEL ,RXD Muxed Input Selected." "0,1"
        textline "    "
        bitfld.long 0x00 3. " DTRDEN ,Data Terminal Ready Delta Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKEN ,Asynchronous WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINTEN ,Asynchronous IR WAKE Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDSEN ,Receive Status Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 7. " ADNIMP ,Autobaud Detection Not Improved-." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RI ,Ring Indicator ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " DCD ,Data Carrier Detect ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " DSR ,Data Set Ready ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " FRAERREN ,Frame Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 12. " PARERREN ,Parity Error Interrupt Enable." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTREN ,Data Terminal Ready Interrupt Enable ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 14.--16. 1. " DPEC ,DTR/DSR Interrupt Edge Control ."
width 5.
group.long 0x8c++0x3
    line.long 0x00 "UCR4,UART Control Register 4"
        bitfld.long 0x00 0. " DREN ,Receive Data Ready Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " OREN ,Receiver Overrun Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BKEN ,BREAK Condition Detected Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TCEN ,Transmit Complete Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " LPBYP ,Low Power Bypass ." "0,1"
        textline "    "
        bitfld.long 0x00 5. " IRSC ,IR Special Case ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " IDDMAEN ,DMA IDLE Condition Detected Interrupt Enable Enables/Disables the receive DMA request dma_req_rx for the IDLE interrupt (triggered with IDLE flag in USR2[12])." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WKEN ,WAKE Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " ENIRI ,Serial Infrared Interrupt Enable ." "0,1"
        textline "    "
        bitfld.long 0x00 9. " INVR ,Invert RXD input in RS-232/RS-485 Mode, d etermine RXD input logic level being sampled in In IrDA mode." "0,1"
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " CTSTL ,CTS Trigger Level ."
width 5.
group.long 0x90++0x3
    line.long 0x00 "UFCR,UART FIFO Control Register"
        hexmask.long.byte 0x00 0.--6. 1. " RXTL ,Receiver Trigger Level ."
        textline "    "
        bitfld.long 0x00 6. " DCEDTE ,DCE/DTE mode select ." "0,1"
        textline "    "
        hexmask.long.byte 0x00 7.--10. 1. " RFDIV ,Reference Frequency Divider."
        textline "    "
        hexmask.long.byte 0x00 10.--16. 1. " TXTL ,Transmitter Trigger Level ."
width 5.
group.long 0x94++0x3
    line.long 0x00 "USR1,UART Status Register 1"
        bitfld.long 0x00 3. " SAD ,RS-485 Slave Address Detected Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 4. " AWAKE ,Asynchronous WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " AIRINT ,Asynchronous IR WAKE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 6. " RXDS ,Receiver IDLE Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 7. " DTRD ,DTR Delta." "0,1"
        textline "    "
        bitfld.long 0x00 8. " AGTIM ,Ageing Timer Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RRDY ,Receiver Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " FRAMERR ,Frame Error Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ESCF ,Escape Sequence Interrupt Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " RTSD ,RTS Delta." "0,1"
        textline "    "
        bitfld.long 0x00 13. " TRDY ,Transmitter Ready Interrupt / DMA Flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " RTSS ,RTS Pin Status ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " PARITYERR ,Parity Error Interrupt Flag ." "0,1"
width 5.
group.long 0x98++0x3
    line.long 0x00 "USR2,UART Status Register 2"
        bitfld.long 0x00 0. " RDR ,Receive Data Ready -Indicates that at least 1 character is received and written to the RxFIFO." "0,1"
        textline "    "
        bitfld.long 0x00 1. " ORE ,Overrun Error ." "0,1"
        textline "    "
        bitfld.long 0x00 2. " BRCD ,BREAK Condition Detected ." "0,1"
        textline "    "
        bitfld.long 0x00 3. " TXDC ,Transmitter Complete ." "0,1"
        textline "    "
        bitfld.long 0x00 4. " RTSF ,RTS Edge Triggered Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 5. " DCDIN ,Data Carrier Detect Input ." "0,1"
        textline "    "
        bitfld.long 0x00 6. " DCDDELT ,Data Carrier Detect Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 7. " WAKE ,Wake ." "0,1"
        textline "    "
        bitfld.long 0x00 8. " IRINT ,Serial Infrared Interrupt Flag." "0,1"
        textline "    "
        bitfld.long 0x00 9. " RIIN ,Ring Indicator Input ." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RIDELT ,Ring Indicator Delta ." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ACST ,Autobaud Counter Stopped ." "0,1"
        textline "    "
        bitfld.long 0x00 12. " IDLE ,Idle Condition ." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DTRF ,DTR edge triggered interrupt flag ." "0,1"
        textline "    "
        bitfld.long 0x00 14. " TXFE ,Transmit Buffer FIFO Empty ." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ADET ,Automatic Baud Rate Detect Complete ." "0,1"
width 5.
group.long 0x9c++0x3
    line.long 0x00 "UESC,UART Escape Character Register"
        hexmask.long.byte 0x00 0.--8. 1. " ESC_CHAR ,UART Escape Character ."
width 5.
group.long 0xa0++0x3
    line.long 0x00 "UTIM,UART Escape Timer Register"
        hexmask.long.word 0x00 0.--12. 1. " TIM ,UART Escape Timer."
width 5.
group.long 0xa4++0x3
    line.long 0x00 "UBIR,UART BRM Incremental Register"
        hexmask.long.word 0x00 0.--16. 1. " INC ,Incremental Numerator."
width 5.
group.long 0xa8++0x3
    line.long 0x00 "UBMR,UART BRM Modulator Register"
        hexmask.long.word 0x00 0.--16. 1. " MOD ,Modulator Denominator."
width 5.
rgroup.long 0xac++0x3
    line.long 0x00 "UBRC,UART Baud Rate Count Register"
        hexmask.long.word 0x00 0.--16. 1. " BCNT ,Baud Rate Count Register."
width 6.
group.long 0xb0++0x3
    line.long 0x00 "ONEMS,UART One Millisecond Register"
        hexmask.long.long 0x00 0.--24. 1. " ONEMS ,One Millisecond Register."
width 4.
group.long 0xb4++0x3
    line.long 0x00 "UTS,UART Test Register"
        bitfld.long 0x00 0. " SOFTRST ,Software Reset." "0,1"
        textline "   "
        bitfld.long 0x00 3. " RXFULL ,RxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 4. " TXFULL ,TxFIFO FULL." "0,1"
        textline "   "
        bitfld.long 0x00 5. " RXEMPTY ,RxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 6. " TXEMPTY ,TxFIFO Empty." "0,1"
        textline "   "
        bitfld.long 0x00 9. " RXDBG ,RX_fifo_debug_mode." "0,1"
        textline "   "
        bitfld.long 0x00 10. " LOOPIR ,Loop TX and RX for IR Test (LOOPIR) ." "0,1"
        textline "   "
        bitfld.long 0x00 11. " DBGEN ,debug_enable ." "0,1"
        textline "   "
        bitfld.long 0x00 12. " LOOP ,Loop TX and RX for Test." "0,1"
        textline "   "
        bitfld.long 0x00 13. " FRCPERR ,Force Parity Error." "0,1"
width 5.
group.long 0xb8++0x3
    line.long 0x00 "UMCR,UART RS-485 Mode Control Register"
        bitfld.long 0x00 0. " MDEN ,9-bit data or Multidrop Mode (RS-485) Enable." "0,1"
        textline "    "
        bitfld.long 0x00 1. " SLAM ,RS-485 Slave Address Detect Mode Selection." "0,1"
        textline "    "
        bitfld.long 0x00 2. " TXB8 ,Transmit RS-485 bit 8 (the ninth bit or 9 th bit)." "0,1"
        textline "    "
        bitfld.long 0x00 3. " SADEN ,RS-485 Slave Address Detected Interrupt Enable." "0,1"
        textline "    "
        hexmask.long.byte 0x00 8.--16. 1. " SLADDR ,RS-485 Slave Address Character."


    tree.end

tree.end



;--------------------------------------------------------------------------------
; USB_ANALOG
;--------------------------------------------------------------------------------
tree "USB_ANALOG"
    base ad:0x020c8000

width 17.
group.long 0x1a0++0x3
    line.long 0x00 "USB1_VBUS_DETECT,USB VBUS Detect Register"
        hexmask.long.byte 0x00 0.--3. 1. " VBUSVALID_THRESH ,Set the threshold for the VBUSVALID comparator."
        textline "                "
        bitfld.long 0x00 20. " VBUSVALID_PWRUP_CMPS ,Powers up comparators for vbus_valid detector." "0,1"
        textline "                "
        bitfld.long 0x00 26. " DISCHARGE_VBUS ,USB OTG discharge VBUS." "0,1"
        textline "                "
        bitfld.long 0x00 27. " CHARGE_VBUS ,USB OTG charge VBUS." "0,1"
width 17.
group.long 0x1b0++0x3
    line.long 0x00 "USB1_CHRG_DETECT,USB Charger Detect Register"
        bitfld.long 0x00 18. " CHK_CONTACT ," "0,1"
        textline "                "
        bitfld.long 0x00 19. " CHK_CHRG_B ," "0,1"
        textline "                "
        bitfld.long 0x00 20. " EN_B ,Control the charger detector." "0,1"
width 22.
rgroup.long 0x1c0++0x3
    line.long 0x00 "USB1_VBUS_DETECT_STAT,USB VBUS Detect Status Register"
        bitfld.long 0x00 0. " SESSEND ,Session End for USB OTG." "0,1"
        textline "                     "
        bitfld.long 0x00 1. " BVALID ,Indicates VBus is valid for a B-peripheral." "0,1"
        textline "                     "
        bitfld.long 0x00 2. " AVALID ,Indicates VBus is valid for a A-peripheral." "0,1"
        textline "                     "
        bitfld.long 0x00 3. " VBUS_VALID ,VBus valid for USB OTG." "0,1"
width 22.
rgroup.long 0x1d0++0x3
    line.long 0x00 "USB1_CHRG_DETECT_STAT,USB Charger Detect Status Register"
        bitfld.long 0x00 0. " PLUG_CONTACT ,State of the USB plug contact detector." "0,1"
        textline "                     "
        bitfld.long 0x00 1. " CHRG_DETECTED ,State of charger detection." "0,1"
        textline "                     "
        bitfld.long 0x00 2. " DM_STATE ,DM line state output of the charger detector." "0,1"
        textline "                     "
        bitfld.long 0x00 3. " DP_STATE ,DP line state output of the charger detector." "0,1"
width 10.
group.long 0x1f0++0x3
    line.long 0x00 "USB1_MISC,USB Misc Register"
        bitfld.long 0x00 0. " HS_USE_EXTERNAL_R ,Use external resistor to generate the current bias for the high speed transmitter." "0,1"
        textline "         "
        bitfld.long 0x00 1. " EN_DEGLITCH ,Enable the deglitching circuit of the USB PLL output." "0,1"
        textline "         "
        bitfld.long 0x00 30. " EN_CLK_UTMI ,Enables the clk to the UTMI block." "0,1"
width 17.
group.long 0x200++0x3
    line.long 0x00 "USB2_VBUS_DETECT,USB VBUS Detect Register"
        hexmask.long.byte 0x00 0.--3. 1. " VBUSVALID_THRESH ,Set the threshold for the VBUSVALID comparator."
        textline "                "
        bitfld.long 0x00 20. " VBUSVALID_PWRUP_CMPS ,Powers up comparators for vbus_valid detector." "0,1"
        textline "                "
        bitfld.long 0x00 26. " DISCHARGE_VBUS ,USB OTG discharge VBUS." "0,1"
        textline "                "
        bitfld.long 0x00 27. " CHARGE_VBUS ,USB OTG charge VBUS." "0,1"
width 17.
group.long 0x210++0x3
    line.long 0x00 "USB2_CHRG_DETECT,USB Charger Detect Register"
        bitfld.long 0x00 18. " CHK_CONTACT ," "0,1"
        textline "                "
        bitfld.long 0x00 19. " CHK_CHRG_B ," "0,1"
        textline "                "
        bitfld.long 0x00 20. " EN_B ,Control the charger detector." "0,1"
width 22.
rgroup.long 0x220++0x3
    line.long 0x00 "USB2_VBUS_DETECT_STAT,USB VBUS Detect Status Register"
        bitfld.long 0x00 0. " SESSEND ,Session End for USB OTG." "0,1"
        textline "                     "
        bitfld.long 0x00 1. " BVALID ,Indicates VBus is valid for a B-peripheral." "0,1"
        textline "                     "
        bitfld.long 0x00 2. " AVALID ,Indicates VBus is valid for a A-peripheral." "0,1"
        textline "                     "
        bitfld.long 0x00 3. " VBUS_VALID ,VBus valid for USB OTG." "0,1"
width 22.
rgroup.long 0x230++0x3
    line.long 0x00 "USB2_CHRG_DETECT_STAT,USB Charger Detect Status Register"
        bitfld.long 0x00 0. " PLUG_CONTACT ,State of the USB plug contact detector." "0,1"
        textline "                     "
        bitfld.long 0x00 1. " CHRG_DETECTED ,State of charger detection." "0,1"
        textline "                     "
        bitfld.long 0x00 2. " DM_STATE ,DM line state output of the charger detector." "0,1"
        textline "                     "
        bitfld.long 0x00 3. " DP_STATE ,DP line state output of the charger detector." "0,1"
width 10.
group.long 0x250++0x3
    line.long 0x00 "USB2_MISC,USB Misc Register"
        bitfld.long 0x00 0. " HS_USE_EXTERNAL_R ,Use external resistor to generate the current bias for the high speed transmitter." "0,1"
        textline "         "
        bitfld.long 0x00 1. " EN_DEGLITCH ,Enable the deglitching circuit of the USB PLL output." "0,1"
        textline "         "
        bitfld.long 0x00 30. " EN_CLK_UTMI ,Enables the clk to the UTMI block." "0,1"
width 8.
rgroup.long 0x280++0x3
    line.long 0x00 "DIGPROG,Chip Silicon Version"
        hexmask.long.byte 0x00 0.--8. 1. " MINOR ,Fixed read-only value reflecting the MINOR field of the RTL version."
        textline "       "
        hexmask.long.word 0x00 8.--24. 1. " MAJOR ,Fixed read-only value reflecting the MAJOR field of the RTL version."


tree.end



;--------------------------------------------------------------------------------
; USBC
;--------------------------------------------------------------------------------
tree "USBC"
    base ad:0x02184000

width 8.
rgroup.long 0x0++0x3
    line.long 0x00 "UOG1_ID,Identification register"
        hexmask.long.byte 0x00 0.--6. 1. " ID ,Configuration number."
        textline "       "
        hexmask.long.byte 0x00 8.--14. 1. " NID ,Complement version of ID"
        textline "       "
        hexmask.long.byte 0x00 16.--24. 1. " REVISION ,Revision number of the controller core."
width 15.
rgroup.long 0x4++0x3
    line.long 0x00 "UOG1_HWGENERAL,Hardware General"
        hexmask.long.byte 0x00 4.--6. 1. " PHYW ,Data width of the transciever connected to the controller core."
        textline "              "
        hexmask.long.byte 0x00 6.--9. 1. " PHYM ,Transciever type PHYM bit reset value: '0000b' for OTG controller core, '0100b' for Host-only controller core."
        textline "              "
        hexmask.long.byte 0x00 9.--11. 1. " SM ,Serial interface mode capability SM bit reset value is '00b'"
width 12.
rgroup.long 0x8++0x3
    line.long 0x00 "UOG1_HWHOST,Host Hardware Parameters"
        bitfld.long 0x00 0. " HC ,Host Capable." "0,1"
        textline "           "
        hexmask.long.byte 0x00 1.--4. 1. " NPORT ,The Nmber of downstream ports supported by the host controller is (NPORT+1)."
width 14.
rgroup.long 0xc++0x3
    line.long 0x00 "UOG1_HWDEVICE,Device Hardware Parameters"
        bitfld.long 0x00 0. " DC ,Device Capable." "0,1"
        textline "             "
        hexmask.long.byte 0x00 1.--6. 1. " DEVEP ,Device Endpoint Number"
width 13.
rgroup.long 0x10++0x3
    line.long 0x00 "UOG1_HWTXBUF,TX Buffer Hardware Parameters"
        hexmask.long.byte 0x00 0.--8. 1. " TXBURST ,Default burst size for memory to TX buffer transfer."
        textline "            "
        hexmask.long.byte 0x00 16.--24. 1. " TXCHANADD ,TX FIFO Buffer size is: (2^TXCHANADD) * 4 Bytes."
width 13.
rgroup.long 0x14++0x3
    line.long 0x00 "UOG1_HWRXBUF,RX Buffer Hardware Parameters"
        hexmask.long.byte 0x00 0.--8. 1. " RXBURST ,Default burst size for memory to RX buffer transfer."
        textline "            "
        hexmask.long.byte 0x00 8.--16. 1. " RXADD ,Buffer total size for all receive endpoints is (2^RXADD)."
width 16.
group.long 0x80++0x3
    line.long 0x00 "UOG1_GPTIMER0LD,General Purpose Timer #0 Load"
        hexmask.long.long 0x00 0.--24. 1. " GPTLD ,General Purpose Timer Load Value These bit fields are loaded to GPTCNT bits when GPTRST bit is set '1b'."
width 18.
group.long 0x84++0x3
    line.long 0x00 "UOG1_GPTIMER0CTRL,General Purpose Timer #0 Controller"
        hexmask.long.long 0x00 0.--24. 1. " GPTCNT ,General Purpose Timer Counter."
        textline "                 "
        bitfld.long 0x00 24. " GPTMODE ,General Purpose Timer Mode In one shot mode, the timer will count down to zero, generate an interrupt, and stop until the counter is reset by software; In repeat mode, the timer will count down to zero, generate an interrupt and automatically reload the counter value from GPTLD bits to start again." "0,1"
        textline "                 "
        bitfld.long 0x00 30. " GPTRST ,General Purpose Timer Reset" "0,1"
        textline "                 "
        bitfld.long 0x00 31. " GPTRUN ,General Purpose Timer Run GPTCNT bits are not effected when setting or clearing this bit." "0,1"
width 16.
group.long 0x88++0x3
    line.long 0x00 "UOG1_GPTIMER1LD,General Purpose Timer #1 Load"
        hexmask.long.long 0x00 0.--24. 1. " GPTLD ,General Purpose Timer Load Value These bit fields are loaded to GPTCNT bits when GPTRST bit is set '1b'."
width 18.
group.long 0x8c++0x3
    line.long 0x00 "UOG1_GPTIMER1CTRL,General Purpose Timer #1 Controller"
        hexmask.long.long 0x00 0.--24. 1. " GPTCNT ,General Purpose Timer Counter."
        textline "                 "
        bitfld.long 0x00 24. " GPTMODE ,General Purpose Timer Mode In one shot mode, the timer will count down to zero, generate an interrupt, and stop until the counter is reset by software." "0,1"
        textline "                 "
        bitfld.long 0x00 30. " GPTRST ,General Purpose Timer Reset" "0,1"
        textline "                 "
        bitfld.long 0x00 31. " GPTRUN ,General Purpose Timer Run GPTCNT bits are not effected when setting or clearing this bit." "0,1"
width 13.
group.long 0x90++0x3
    line.long 0x00 "UOG1_SBUSCFG,System Bus Config"
        hexmask.long.byte 0x00 0.--3. 1. " AHBBRST ,AHB master interface Burst configuration These bits control AHB master transfer type sequence (or priority)."
width 15.
rgroup.byte 0x100++0x0
    line.byte 0x00 "UOG1_CAPLENGTH,Capability Registers Length"
        hexmask.byte.byte 0x00 0.--8. 1. " CAPLENGTH ,These bits are used as an offset to add to register base to find the beginning of the Operational Register."
width 16.
rgroup.word 0x102++0x1
    line.word 0x00 "UOG1_HCIVERSION,Host Controller Interface Version"
        hexmask.word.word 0x00 0.--16. 1. " HCIVERSION ,Host Controller Interface Version Number Default value is '10h', which means EHCI rev1.0."
width 15.
rgroup.long 0x104++0x3
    line.long 0x00 "UOG1_HCSPARAMS,Host Controller Structural Parameters"
        hexmask.long.byte 0x00 0.--4. 1. " N_PORTS ,Number of downstream ports."
        textline "              "
        bitfld.long 0x00 4. " PPC ,Port Power Control This field indicates whether the host controller implementation includes port power control." "0,1"
        textline "              "
        hexmask.long.byte 0x00 8.--12. 1. " N_PCC ,Number of Ports per Companion Controller This field indicates the number of ports supported per internal Companion Controller."
        textline "              "
        hexmask.long.byte 0x00 12.--16. 1. " N_CC ,Number of Companion Controller (N_CC)."
        textline "              "
        bitfld.long 0x00 16. " PI ,Port Indicators (P INDICATOR) This bit indicates whether the ports support port indicator control." "0,1"
        textline "              "
        hexmask.long.byte 0x00 20.--24. 1. " N_PTT ,Number of Ports per Transaction Translator (N_PTT)."
        textline "              "
        hexmask.long.byte 0x00 24.--28. 1. " N_TT ,Number of Transaction Translators (N_TT)."
width 15.
rgroup.long 0x108++0x3
    line.long 0x00 "UOG1_HCCPARAMS,Host Controller Capability Parameters"
        bitfld.long 0x00 0. " ADC ,64-bit Addressing Capability This bit is set '0b' in all controller core, no 64-bit addressing capability is supported." "0,1"
        textline "              "
        bitfld.long 0x00 1. " PFL ,Programmable Frame List Flag If this bit is set to zero, then the system software must use a frame list length of 1024 elements with this host controller." "0,1"
        textline "              "
        bitfld.long 0x00 2. " ASP ,Asynchronous Schedule Park Capability If this bit is set to a one, then the host controller supports the park feature for high-speed queue heads in the Asynchronous Schedule." "0,1"
        textline "              "
        hexmask.long.byte 0x00 4.--8. 1. " IST ,Isochronous Scheduling Threshold."
        textline "              "
        hexmask.long.byte 0x00 8.--16. 1. " EECP ,EHCI Extended Capabilities Pointer."
width 16.
rgroup.word 0x120++0x1
    line.word 0x00 "UOG1_DCIVERSION,Device Controller Interface Version"
        hexmask.word.word 0x00 0.--16. 1. " DCIVERSION ,Device Controller Interface Version Number Default value is '01h', which means rev0.1."
width 15.
rgroup.long 0x124++0x3
    line.long 0x00 "UOG1_DCCPARAMS,Device Controller Capability Parameters"
        hexmask.long.byte 0x00 0.--5. 1. " DEN ,Device Endpoint Number This field indicates the number of endpoints built into the device controller."
        textline "              "
        bitfld.long 0x00 7. " DC ,Device Capable When this bit is 1, this controller is capable of operating as a USB 2.0 device." "0,1"
        textline "              "
        bitfld.long 0x00 8. " HC ,Host Capable When this bit is 1, this controller is capable of operating as an EHCI compatible USB 2.0 host controller." "0,1"
width 12.
group.long 0x140++0x3
    line.long 0x00 "UOG1_USBCMD,USB Command Register"
        bitfld.long 0x00 0. " RS ,Run/Stop (RS) - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 1. " RST ,Controller Reset (RESET) - Read/Write." "0,1"
        textline "           "
        hexmask.long.byte 0x00 2.--4. 1. " FS_1 ,See description at bit 15"
        textline "           "
        bitfld.long 0x00 4. " PSE ,Periodic Schedule Enable- Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 5. " ASE ,Asynchronous Schedule Enable - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 6. " IAA ,Interrupt on Async Advance Doorbell - Read/Write." "0,1"
        textline "           "
        hexmask.long.byte 0x00 8.--10. 1. " ASP ,Asynchronous Schedule Park Mode Count - Read/Write."
        textline "           "
        bitfld.long 0x00 11. " ASPE ,Asynchronous Schedule Park Mode Enable - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 13. " SUTW ,Setup TripWire - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 14. " ATDTW ,Add dTD TripWire - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 15. " FS_2 ,See also bits 3-2 Frame List Size - (Read/Write or Read Only)." "0,1"
        textline "           "
        hexmask.long.byte 0x00 16.--24. 1. " ITC ,Interrupt Threshold Control -Read/Write."
width 12.
group.long 0x144++0x3
    line.long 0x00 "UOG1_USBSTS,USB Status Register"
        bitfld.long 0x00 0. " UI ,USB Interrupt (USBINT) - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 1. " UEI ,USB Error Interrupt (USBERRINT) - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 2. " PCI ,Port Change Detect - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 3. " FRI ,Frame List Rollover - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 4. " SEI ,System Error- R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 5. " AAI ,Interrupt on Async Advance - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 6. " URI ,USB Reset Received - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 7. " SRI ,SOF Received - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 8. " SLI ,DCSuspend - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 10. " ULPII ,ULPI Interrupt - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 12. " HCH ,HCHaIted - Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 13. " RCL ,Reclamation - Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 14. " PS ,Periodic Schedule Status - Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 15. " AS ,Asynchronous Schedule Status - Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 16. " NAKI ,NAK Interrupt Bit--RO." "0,1"
        textline "           "
        bitfld.long 0x00 24. " TI0 ,General Purpose Timer Interrupt 0(GPTINT0)--R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 25. " TI1 ,General Purpose Timer Interrupt 1(GPTINT1)--R/WC." "0,1"
width 13.
group.long 0x148++0x3
    line.long 0x00 "UOG1_USBINTR,Interrupt Enable Register"
        bitfld.long 0x00 0. " UE ,USB Interrupt Enalbe When this bit is one and the UI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 1. " UEE ,USB Error Interrupt Enable When this bit is one and the UEI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 2. " PCE ,Port Change Detect Interrupt Enable When this bit is one and the PCI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 3. " FRE ,Frame List Rollover Interrupt Enable When this bit is one and the FRI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 4. " SEE ,System Error Interrupt Enable When this bit is one and the SEI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 5. " AAE ,Async Advance Interrupt Enable When this bit is one and the AAI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 6. " URE ,USB Reset Interrupt Enable When this bit is one and the URI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 7. " SRE ,SOF Received Interrupt Enable When this bit is one and the SRI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 8. " SLE ,Sleep Interrupt Enable When this bit is one and the SLI bit in n_n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 10. " ULPIE ,ULPI Interrupt Enable When this bit is one and the UPLII bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 16. " NAKE ,NAK Interrupt Enable When this bit is one and the NAKI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 18. " UAIE ,USB Host Asynchronous Interrupt Enable When this bit is one, and the UAI bit in the n_USBSTS register is one, host controller will issue an interrupt at the next interrupt threshold." "0,1"
        textline "            "
        bitfld.long 0x00 19. " UPIE ,USB Host Periodic Interrupt Enable When this bit is one, and the UPI bit in the n_USBSTS register is one, host controller will issue an interrupt at the next interrupt threshold." "0,1"
        textline "            "
        bitfld.long 0x00 24. " TIE0 ,General Purpose Timer #0 Interrupt Enable When this bit is one and the TI0 bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 25. " TIE1 ,General Purpose Timer #1 Interrupt Enable When this bit is one and the TI1 bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
width 13.
group.long 0x14c++0x3
    line.long 0x00 "UOG1_FRINDEX,USB Frame Index"
        hexmask.long.word 0x00 0.--14. 1. " FRINDEX ,Frame Index."
width 22.
group.long 0x154++0x3
    line.long 0x00 "UOG1_PERIODICLISTBASE,Frame List Base Address"
        hexmask.long.long 0x00 12.--32. 1. " BASEADR ,Base Address (Low)."
width 16.
group.long 0x154++0x3
    line.long 0x00 "UOG1_DEVICEADDR,Device Address"
        bitfld.long 0x00 24. " USBADRA ,Device Address Advance." "0,1"
        textline "               "
        hexmask.long.byte 0x00 25.--32. 1. " USBADR ,Device Address."
width 19.
group.long 0x158++0x3
    line.long 0x00 "UOG1_ASYNCLISTADDR,Next Asynch. Address"
        hexmask.long.long 0x00 5.--32. 1. " ASYBASE ,Link Pointer Low (LPL)."
width 19.
group.long 0x158++0x3
    line.long 0x00 "UOG1_ENDPTLISTADDR,Endpoint List Address"
        hexmask.long.long 0x00 11.--32. 1. " EPBASE ,Endpoint List Pointer(Low)."
width 15.
group.long 0x160++0x3
    line.long 0x00 "UOG1_BURSTSIZE,Programmable Burst Size"
        hexmask.long.byte 0x00 0.--8. 1. " RXPBURST ,Programmable RX Burst Size."
        textline "              "
        hexmask.long.word 0x00 8.--17. 1. " TXPBURST ,Programmable TX Burst Size."
width 18.
group.long 0x164++0x3
    line.long 0x00 "UOG1_TXFILLTUNING,TX FIFO Fill Tuning"
        hexmask.long.byte 0x00 0.--8. 1. " TXSCHOH ,Scheduler Overhead."
        textline "                 "
        hexmask.long.byte 0x00 8.--13. 1. " TXSCHHEALTH ,Scheduler Health Counter."
        textline "                 "
        hexmask.long.byte 0x00 16.--22. 1. " TXFIFOTHRES ,FIFO Burst Threshold."
width 14.
group.long 0x178++0x3
    line.long 0x00 "UOG1_ENDPTNAK,Endpoint NAK"
        hexmask.long.byte 0x00 0.--8. 1. " EPRN ,RX Endpoint NAK - R/WC."
        textline "             "
        hexmask.long.byte 0x00 16.--24. 1. " EPTN ,TX Endpoint NAK - R/WC."
width 16.
group.long 0x17c++0x3
    line.long 0x00 "UOG1_ENDPTNAKEN,Endpoint NAK Enable"
        hexmask.long.byte 0x00 0.--8. 1. " EPRNE ,RX Endpoint NAK Enable - R/W."
        textline "               "
        hexmask.long.byte 0x00 16.--24. 1. " EPTNE ,TX Endpoint NAK Enable - R/W."
width 16.
group.long 0x180++0x3
    line.long 0x00 "UOG1_CONFIGFLAG,Configure Flag Register"
        bitfld.long 0x00 0. " CF ,Configure Flag Host software sets this bit as the last action in its process of configuring the Host Controller." "0,1"
width 13.
group.long 0x184++0x3
    line.long 0x00 "UOG1_PORTSC1,Port Status & Control"
        bitfld.long 0x00 0. " CCS ,Current Connect Status-Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 1. " CSC ,Connect Status Change-R/WC." "0,1"
        textline "            "
        bitfld.long 0x00 2. " PE ,Port Enabled/Disabled-Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 3. " PEC ,Port Enable/Disable Change-R/WC." "0,1"
        textline "            "
        bitfld.long 0x00 4. " OCA ,Over-current Active-Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 5. " OCC ,Over-current Change-R/WC." "0,1"
        textline "            "
        bitfld.long 0x00 6. " FPR ,Force Port Resume -Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 7. " SUSP ,Suspend - Read/Write or Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 8. " PR ,Port Reset - Read/Write or Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 9. " HSP ,High-Speed Port - Read Only." "0,1"
        textline "            "
        hexmask.long.byte 0x00 10.--12. 1. " LS ,Line Status-Read Only."
        textline "            "
        bitfld.long 0x00 12. " PP ,Port Power (PP)-Read/Write or Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 13. " PO ,Port Owner-Read/Write." "0,1"
        textline "            "
        hexmask.long.byte 0x00 14.--16. 1. " PIC ,Port Indicator Control - Read/Write."
        textline "            "
        hexmask.long.byte 0x00 16.--20. 1. " PTC ,Port Test Control - Read/Write."
        textline "            "
        bitfld.long 0x00 20. " WKCN ,Wake on Connect Enable (WKCNNT_E) - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 21. " WKDC ,Wake on Disconnect Enable (WKDSCNNT_E) - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 22. " WKOC ,Wake on Over-current Enable (WKOC_E) - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 23. " PHCD ,PHY Low Power Suspend - Clock Disable (PLPSCD) - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 24. " PFSC ,Port Force Full Speed Connect - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 25. " PTS_2 ,See description at bits 31-30" "0,1"
        textline "            "
        hexmask.long.byte 0x00 26.--28. 1. " PSPD ,Port Speed - Read Only."
        textline "            "
        bitfld.long 0x00 28. " PTW ,Parallel Transceiver Width This bit has no effect if serial interface engine is used." "0,1"
        textline "            "
        bitfld.long 0x00 29. " STS ,Serial Transceiver Select - Read Only Serial Transceiver Select 1 Serial Interface Engine is selected 0 Parallel Interface signals is selected Serial Interface Engine can be used in combination with UTMI+/ULPI physical interface to provide FS/LS signaling instead of the parallel interface signals." "0,1"
        textline "            "
        hexmask.long.byte 0x00 30.--32. 1. " PTS_1 ,Bit field {bit25, bit31, bit30}: ""000b"" UTMI/UTMI+ ""001b"" Reserved ""010b"" ULPI ""011b"" Serial/USB 1.1 PHY/IC-USB (FS Only) ""100b"" HSIC All USB port interface modes are listed in this field description, but not all are supported."
width 11.
group.long 0x1a4++0x3
    line.long 0x00 "UOG1_OTGSC,On-The-Go Status & control"
        bitfld.long 0x00 0. " VD ,VBUS_Discharge - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 1. " VC ,VBUS Charge - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 3. " OT ,OTG Termination - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 4. " DP ,Data Pulsing - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 5. " IDPU ,ID Pullup - Read/Write This bit provide control over the ID pull-up resister; 0 = off, 1 = on [default]." "0,1"
        textline "          "
        bitfld.long 0x00 8. " ID ,USB ID - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 9. " AVV ,A VBus Valid - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 10. " ASV ,A Session Valid - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 11. " BSV ,B Session Valid - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 12. " BSE ,B Session End - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 13. " _1MST ,1 millisecond timer toggle - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 14. " DPS ,Data Bus Pulsing Status - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 16. " IDIS ,USB ID Interrupt Status - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 17. " AVVIS ,A VBus Valid Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 18. " ASVIS ,A Session Valid Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 19. " BSVIS ,B Session Valid Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 20. " BSEIS ,B Session End Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 21. " _1MSS ,1 millisecond timer Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 22. " DPIS ,Data Pulse Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 24. " IDIE ,USB ID Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 25. " AVVIE ,A VBus Valid Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 26. " ASVIE ,A Session Valid Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 27. " BSVIE ,B Session Valid Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 28. " BSEIE ,B Session End Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 29. " _1MSE ,1 millisecond timer Interrupt Enable - Read/Write" "0,1"
        textline "          "
        bitfld.long 0x00 30. " DPIE ,Data Pulse Interrupt Enable" "0,1"
width 13.
group.long 0x1a8++0x3
    line.long 0x00 "UOG1_USBMODE,USB Device Mode"
        hexmask.long.byte 0x00 0.--2. 1. " CM ,Controller Mode - R/WO."
        textline "            "
        bitfld.long 0x00 2. " ES ,Endian Select - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 3. " SLOM ,Setup Lockout Mode." "0,1"
        textline "            "
        bitfld.long 0x00 4. " SDIS ,Stream Disable Mode." "0,1"
width 20.
group.long 0x1ac++0x3
    line.long 0x00 "UOG1_ENDPTSETUPSTAT,Endpoint Setup Status"
        hexmask.long.word 0x00 0.--16. 1. " ENDPTSETUPSTAT ,Setup Endpoint Status."
width 16.
group.long 0x1b0++0x3
    line.long 0x00 "UOG1_ENDPTPRIME,Endpoint Prime"
        hexmask.long.byte 0x00 0.--8. 1. " PERB ,Prime Endpoint Receive Buffer - R/WS."
        textline "               "
        hexmask.long.byte 0x00 16.--24. 1. " PETB ,Prime Endpoint Transmit Buffer - R/WS."
width 16.
group.long 0x1b4++0x3
    line.long 0x00 "UOG1_ENDPTFLUSH,Endpoint Flush"
        hexmask.long.byte 0x00 0.--8. 1. " FERB ,Flush Endpoint Receive Buffer - R/WS."
        textline "               "
        hexmask.long.byte 0x00 16.--24. 1. " FETB ,Flush Endpoint Transmit Buffer - R/WS."
width 15.
rgroup.long 0x1b8++0x3
    line.long 0x00 "UOG1_ENDPTSTAT,Endpoint Status"
        hexmask.long.byte 0x00 0.--8. 1. " ERBR ,Endpoint Receive Buffer Ready -- Read Only."
        textline "              "
        hexmask.long.byte 0x00 16.--24. 1. " ETBR ,Endpoint Transmit Buffer Ready -- Read Only."
width 19.
group.long 0x1bc++0x3
    line.long 0x00 "UOG1_ENDPTCOMPLETE,Endpoint Complete"
        hexmask.long.byte 0x00 0.--8. 1. " ERCE ,Endpoint Receive Complete Event - RW/C."
        textline "                  "
        hexmask.long.byte 0x00 16.--24. 1. " ETCE ,Endpoint Transmit Complete Event - R/WC."
width 16.
group.long 0x1c0++0x3
    line.long 0x00 "UOG1_ENDPTCTRL0,Endpoint Control0"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control Endpoint0 is fixed as a Control End Point."
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 1 Enabled Endpoint0 is always enabled." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK [Default] 1 End Point Stalled Software can write a one to this bit to force the endpoint to return a STALL handshake to the Host." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 - Control Endpoint0 is fixed as a Control End Point."
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 1 Enabled Endpoint0 is always enabled." "0,1"
width 16.
group.long 0x1c4++0x3
    line.long 0x00 "UOG1_ENDPTCTRL1,Endpoint Control 1"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x1c8++0x3
    line.long 0x00 "UOG1_ENDPTCTRL2,Endpoint Control 2"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x1cc++0x3
    line.long 0x00 "UOG1_ENDPTCTRL3,Endpoint Control 3"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x1d0++0x3
    line.long 0x00 "UOG1_ENDPTCTRL4,Endpoint Control 4"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x1d4++0x3
    line.long 0x00 "UOG1_ENDPTCTRL5,Endpoint Control 5"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x1d8++0x3
    line.long 0x00 "UOG1_ENDPTCTRL6,Endpoint Control 6"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x1dc++0x3
    line.long 0x00 "UOG1_ENDPTCTRL7,Endpoint Control 7"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 8.
rgroup.long 0x200++0x3
    line.long 0x00 "UOG2_ID,Identification register"
        hexmask.long.byte 0x00 0.--6. 1. " ID ,Configuration number."
        textline "       "
        hexmask.long.byte 0x00 8.--14. 1. " NID ,Complement version of ID"
        textline "       "
        hexmask.long.byte 0x00 16.--24. 1. " REVISION ,Revision number of the controller core."
width 15.
rgroup.long 0x204++0x3
    line.long 0x00 "UOG2_HWGENERAL,Hardware General"
        hexmask.long.byte 0x00 4.--6. 1. " PHYW ,Data width of the transciever connected to the controller core."
        textline "              "
        hexmask.long.byte 0x00 6.--9. 1. " PHYM ,Transciever type PHYM bit reset value: '0000b' for OTG controller core, '0100b' for Host-only controller core."
        textline "              "
        hexmask.long.byte 0x00 9.--11. 1. " SM ,Serial interface mode capability SM bit reset value is '00b'"
width 12.
rgroup.long 0x208++0x3
    line.long 0x00 "UOG2_HWHOST,Host Hardware Parameters"
        bitfld.long 0x00 0. " HC ,Host Capable." "0,1"
        textline "           "
        hexmask.long.byte 0x00 1.--4. 1. " NPORT ,The Nmber of downstream ports supported by the host controller is (NPORT+1)."
width 14.
rgroup.long 0x20c++0x3
    line.long 0x00 "UOG2_HWDEVICE,Device Hardware Parameters"
        bitfld.long 0x00 0. " DC ,Device Capable." "0,1"
        textline "             "
        hexmask.long.byte 0x00 1.--6. 1. " DEVEP ,Device Endpoint Number"
width 13.
rgroup.long 0x210++0x3
    line.long 0x00 "UOG2_HWTXBUF,TX Buffer Hardware Parameters"
        hexmask.long.byte 0x00 0.--8. 1. " TXBURST ,Default burst size for memory to TX buffer transfer."
        textline "            "
        hexmask.long.byte 0x00 16.--24. 1. " TXCHANADD ,TX FIFO Buffer size is: (2^TXCHANADD) * 4 Bytes."
width 13.
rgroup.long 0x214++0x3
    line.long 0x00 "UOG2_HWRXBUF,RX Buffer Hardware Parameters"
        hexmask.long.byte 0x00 0.--8. 1. " RXBURST ,Default burst size for memory to RX buffer transfer."
        textline "            "
        hexmask.long.byte 0x00 8.--16. 1. " RXADD ,Buffer total size for all receive endpoints is (2^RXADD)."
width 16.
group.long 0x280++0x3
    line.long 0x00 "UOG2_GPTIMER0LD,General Purpose Timer #0 Load"
        hexmask.long.long 0x00 0.--24. 1. " GPTLD ,General Purpose Timer Load Value These bit fields are loaded to GPTCNT bits when GPTRST bit is set '1b'."
width 18.
group.long 0x284++0x3
    line.long 0x00 "UOG2_GPTIMER0CTRL,General Purpose Timer #0 Controller"
        hexmask.long.long 0x00 0.--24. 1. " GPTCNT ,General Purpose Timer Counter."
        textline "                 "
        bitfld.long 0x00 24. " GPTMODE ,General Purpose Timer Mode In one shot mode, the timer will count down to zero, generate an interrupt, and stop until the counter is reset by software; In repeat mode, the timer will count down to zero, generate an interrupt and automatically reload the counter value from GPTLD bits to start again." "0,1"
        textline "                 "
        bitfld.long 0x00 30. " GPTRST ,General Purpose Timer Reset" "0,1"
        textline "                 "
        bitfld.long 0x00 31. " GPTRUN ,General Purpose Timer Run GPTCNT bits are not effected when setting or clearing this bit." "0,1"
width 16.
group.long 0x288++0x3
    line.long 0x00 "UOG2_GPTIMER1LD,General Purpose Timer #1 Load"
        hexmask.long.long 0x00 0.--24. 1. " GPTLD ,General Purpose Timer Load Value These bit fields are loaded to GPTCNT bits when GPTRST bit is set '1b'."
width 18.
group.long 0x28c++0x3
    line.long 0x00 "UOG2_GPTIMER1CTRL,General Purpose Timer #1 Controller"
        hexmask.long.long 0x00 0.--24. 1. " GPTCNT ,General Purpose Timer Counter."
        textline "                 "
        bitfld.long 0x00 24. " GPTMODE ,General Purpose Timer Mode In one shot mode, the timer will count down to zero, generate an interrupt, and stop until the counter is reset by software." "0,1"
        textline "                 "
        bitfld.long 0x00 30. " GPTRST ,General Purpose Timer Reset" "0,1"
        textline "                 "
        bitfld.long 0x00 31. " GPTRUN ,General Purpose Timer Run GPTCNT bits are not effected when setting or clearing this bit." "0,1"
width 13.
group.long 0x290++0x3
    line.long 0x00 "UOG2_SBUSCFG,System Bus Config"
        hexmask.long.byte 0x00 0.--3. 1. " AHBBRST ,AHB master interface Burst configuration These bits control AHB master transfer type sequence (or priority)."
width 15.
rgroup.byte 0x300++0x0
    line.byte 0x00 "UOG2_CAPLENGTH,Capability Registers Length"
        hexmask.byte.byte 0x00 0.--8. 1. " CAPLENGTH ,These bits are used as an offset to add to register base to find the beginning of the Operational Register."
width 16.
rgroup.word 0x302++0x1
    line.word 0x00 "UOG2_HCIVERSION,Host Controller Interface Version"
        hexmask.word.word 0x00 0.--16. 1. " HCIVERSION ,Host Controller Interface Version Number Default value is '10h', which means EHCI rev1.0."
width 15.
rgroup.long 0x304++0x3
    line.long 0x00 "UOG2_HCSPARAMS,Host Controller Structural Parameters"
        hexmask.long.byte 0x00 0.--4. 1. " N_PORTS ,Number of downstream ports."
        textline "              "
        bitfld.long 0x00 4. " PPC ,Port Power Control This field indicates whether the host controller implementation includes port power control." "0,1"
        textline "              "
        hexmask.long.byte 0x00 8.--12. 1. " N_PCC ,Number of Ports per Companion Controller This field indicates the number of ports supported per internal Companion Controller."
        textline "              "
        hexmask.long.byte 0x00 12.--16. 1. " N_CC ,Number of Companion Controller (N_CC)."
        textline "              "
        bitfld.long 0x00 16. " PI ,Port Indicators (P INDICATOR) This bit indicates whether the ports support port indicator control." "0,1"
        textline "              "
        hexmask.long.byte 0x00 20.--24. 1. " N_PTT ,Number of Ports per Transaction Translator (N_PTT)."
        textline "              "
        hexmask.long.byte 0x00 24.--28. 1. " N_TT ,Number of Transaction Translators (N_TT)."
width 15.
rgroup.long 0x308++0x3
    line.long 0x00 "UOG2_HCCPARAMS,Host Controller Capability Parameters"
        bitfld.long 0x00 0. " ADC ,64-bit Addressing Capability This bit is set '0b' in all controller core, no 64-bit addressing capability is supported." "0,1"
        textline "              "
        bitfld.long 0x00 1. " PFL ,Programmable Frame List Flag If this bit is set to zero, then the system software must use a frame list length of 1024 elements with this host controller." "0,1"
        textline "              "
        bitfld.long 0x00 2. " ASP ,Asynchronous Schedule Park Capability If this bit is set to a one, then the host controller supports the park feature for high-speed queue heads in the Asynchronous Schedule." "0,1"
        textline "              "
        hexmask.long.byte 0x00 4.--8. 1. " IST ,Isochronous Scheduling Threshold."
        textline "              "
        hexmask.long.byte 0x00 8.--16. 1. " EECP ,EHCI Extended Capabilities Pointer."
width 16.
rgroup.word 0x320++0x1
    line.word 0x00 "UOG2_DCIVERSION,Device Controller Interface Version"
        hexmask.word.word 0x00 0.--16. 1. " DCIVERSION ,Device Controller Interface Version Number Default value is '01h', which means rev0.1."
width 15.
rgroup.long 0x324++0x3
    line.long 0x00 "UOG2_DCCPARAMS,Device Controller Capability Parameters"
        hexmask.long.byte 0x00 0.--5. 1. " DEN ,Device Endpoint Number This field indicates the number of endpoints built into the device controller."
        textline "              "
        bitfld.long 0x00 7. " DC ,Device Capable When this bit is 1, this controller is capable of operating as a USB 2.0 device." "0,1"
        textline "              "
        bitfld.long 0x00 8. " HC ,Host Capable When this bit is 1, this controller is capable of operating as an EHCI compatible USB 2.0 host controller." "0,1"
width 12.
group.long 0x340++0x3
    line.long 0x00 "UOG2_USBCMD,USB Command Register"
        bitfld.long 0x00 0. " RS ,Run/Stop (RS) - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 1. " RST ,Controller Reset (RESET) - Read/Write." "0,1"
        textline "           "
        hexmask.long.byte 0x00 2.--4. 1. " FS_1 ,See description at bit 15"
        textline "           "
        bitfld.long 0x00 4. " PSE ,Periodic Schedule Enable- Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 5. " ASE ,Asynchronous Schedule Enable - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 6. " IAA ,Interrupt on Async Advance Doorbell - Read/Write." "0,1"
        textline "           "
        hexmask.long.byte 0x00 8.--10. 1. " ASP ,Asynchronous Schedule Park Mode Count - Read/Write."
        textline "           "
        bitfld.long 0x00 11. " ASPE ,Asynchronous Schedule Park Mode Enable - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 13. " SUTW ,Setup TripWire - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 14. " ATDTW ,Add dTD TripWire - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 15. " FS_2 ,See also bits 3-2 Frame List Size - (Read/Write or Read Only)." "0,1"
        textline "           "
        hexmask.long.byte 0x00 16.--24. 1. " ITC ,Interrupt Threshold Control -Read/Write."
width 12.
group.long 0x344++0x3
    line.long 0x00 "UOG2_USBSTS,USB Status Register"
        bitfld.long 0x00 0. " UI ,USB Interrupt (USBINT) - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 1. " UEI ,USB Error Interrupt (USBERRINT) - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 2. " PCI ,Port Change Detect - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 3. " FRI ,Frame List Rollover - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 4. " SEI ,System Error- R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 5. " AAI ,Interrupt on Async Advance - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 6. " URI ,USB Reset Received - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 7. " SRI ,SOF Received - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 8. " SLI ,DCSuspend - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 10. " ULPII ,ULPI Interrupt - R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 12. " HCH ,HCHaIted - Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 13. " RCL ,Reclamation - Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 14. " PS ,Periodic Schedule Status - Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 15. " AS ,Asynchronous Schedule Status - Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 16. " NAKI ,NAK Interrupt Bit--RO." "0,1"
        textline "           "
        bitfld.long 0x00 24. " TI0 ,General Purpose Timer Interrupt 0(GPTINT0)--R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 25. " TI1 ,General Purpose Timer Interrupt 1(GPTINT1)--R/WC." "0,1"
width 13.
group.long 0x348++0x3
    line.long 0x00 "UOG2_USBINTR,Interrupt Enable Register"
        bitfld.long 0x00 0. " UE ,USB Interrupt Enalbe When this bit is one and the UI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 1. " UEE ,USB Error Interrupt Enable When this bit is one and the UEI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 2. " PCE ,Port Change Detect Interrupt Enable When this bit is one and the PCI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 3. " FRE ,Frame List Rollover Interrupt Enable When this bit is one and the FRI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 4. " SEE ,System Error Interrupt Enable When this bit is one and the SEI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 5. " AAE ,Async Advance Interrupt Enable When this bit is one and the AAI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 6. " URE ,USB Reset Interrupt Enable When this bit is one and the URI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 7. " SRE ,SOF Received Interrupt Enable When this bit is one and the SRI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 8. " SLE ,Sleep Interrupt Enable When this bit is one and the SLI bit in n_n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 10. " ULPIE ,ULPI Interrupt Enable When this bit is one and the UPLII bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 16. " NAKE ,NAK Interrupt Enable When this bit is one and the NAKI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 18. " UAIE ,USB Host Asynchronous Interrupt Enable When this bit is one, and the UAI bit in the n_USBSTS register is one, host controller will issue an interrupt at the next interrupt threshold." "0,1"
        textline "            "
        bitfld.long 0x00 19. " UPIE ,USB Host Periodic Interrupt Enable When this bit is one, and the UPI bit in the n_USBSTS register is one, host controller will issue an interrupt at the next interrupt threshold." "0,1"
        textline "            "
        bitfld.long 0x00 24. " TIE0 ,General Purpose Timer #0 Interrupt Enable When this bit is one and the TI0 bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "            "
        bitfld.long 0x00 25. " TIE1 ,General Purpose Timer #1 Interrupt Enable When this bit is one and the TI1 bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
width 13.
group.long 0x34c++0x3
    line.long 0x00 "UOG2_FRINDEX,USB Frame Index"
        hexmask.long.word 0x00 0.--14. 1. " FRINDEX ,Frame Index."
width 22.
group.long 0x354++0x3
    line.long 0x00 "UOG2_PERIODICLISTBASE,Frame List Base Address"
        hexmask.long.long 0x00 12.--32. 1. " BASEADR ,Base Address (Low)."
width 16.
group.long 0x354++0x3
    line.long 0x00 "UOG2_DEVICEADDR,Device Address"
        bitfld.long 0x00 24. " USBADRA ,Device Address Advance." "0,1"
        textline "               "
        hexmask.long.byte 0x00 25.--32. 1. " USBADR ,Device Address."
width 19.
group.long 0x358++0x3
    line.long 0x00 "UOG2_ASYNCLISTADDR,Next Asynch. Address"
        hexmask.long.long 0x00 5.--32. 1. " ASYBASE ,Link Pointer Low (LPL)."
width 19.
group.long 0x358++0x3
    line.long 0x00 "UOG2_ENDPTLISTADDR,Endpoint List Address"
        hexmask.long.long 0x00 11.--32. 1. " EPBASE ,Endpoint List Pointer(Low)."
width 15.
group.long 0x360++0x3
    line.long 0x00 "UOG2_BURSTSIZE,Programmable Burst Size"
        hexmask.long.byte 0x00 0.--8. 1. " RXPBURST ,Programmable RX Burst Size."
        textline "              "
        hexmask.long.word 0x00 8.--17. 1. " TXPBURST ,Programmable TX Burst Size."
width 18.
group.long 0x364++0x3
    line.long 0x00 "UOG2_TXFILLTUNING,TX FIFO Fill Tuning"
        hexmask.long.byte 0x00 0.--8. 1. " TXSCHOH ,Scheduler Overhead."
        textline "                 "
        hexmask.long.byte 0x00 8.--13. 1. " TXSCHHEALTH ,Scheduler Health Counter."
        textline "                 "
        hexmask.long.byte 0x00 16.--22. 1. " TXFIFOTHRES ,FIFO Burst Threshold."
width 14.
group.long 0x378++0x3
    line.long 0x00 "UOG2_ENDPTNAK,Endpoint NAK"
        hexmask.long.byte 0x00 0.--8. 1. " EPRN ,RX Endpoint NAK - R/WC."
        textline "             "
        hexmask.long.byte 0x00 16.--24. 1. " EPTN ,TX Endpoint NAK - R/WC."
width 16.
group.long 0x37c++0x3
    line.long 0x00 "UOG2_ENDPTNAKEN,Endpoint NAK Enable"
        hexmask.long.byte 0x00 0.--8. 1. " EPRNE ,RX Endpoint NAK Enable - R/W."
        textline "               "
        hexmask.long.byte 0x00 16.--24. 1. " EPTNE ,TX Endpoint NAK Enable - R/W."
width 16.
group.long 0x380++0x3
    line.long 0x00 "UOG2_CONFIGFLAG,Configure Flag Register"
        bitfld.long 0x00 0. " CF ,Configure Flag Host software sets this bit as the last action in its process of configuring the Host Controller." "0,1"
width 13.
group.long 0x384++0x3
    line.long 0x00 "UOG2_PORTSC1,Port Status & Control"
        bitfld.long 0x00 0. " CCS ,Current Connect Status-Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 1. " CSC ,Connect Status Change-R/WC." "0,1"
        textline "            "
        bitfld.long 0x00 2. " PE ,Port Enabled/Disabled-Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 3. " PEC ,Port Enable/Disable Change-R/WC." "0,1"
        textline "            "
        bitfld.long 0x00 4. " OCA ,Over-current Active-Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 5. " OCC ,Over-current Change-R/WC." "0,1"
        textline "            "
        bitfld.long 0x00 6. " FPR ,Force Port Resume -Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 7. " SUSP ,Suspend - Read/Write or Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 8. " PR ,Port Reset - Read/Write or Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 9. " HSP ,High-Speed Port - Read Only." "0,1"
        textline "            "
        hexmask.long.byte 0x00 10.--12. 1. " LS ,Line Status-Read Only."
        textline "            "
        bitfld.long 0x00 12. " PP ,Port Power (PP)-Read/Write or Read Only." "0,1"
        textline "            "
        bitfld.long 0x00 13. " PO ,Port Owner-Read/Write." "0,1"
        textline "            "
        hexmask.long.byte 0x00 14.--16. 1. " PIC ,Port Indicator Control - Read/Write."
        textline "            "
        hexmask.long.byte 0x00 16.--20. 1. " PTC ,Port Test Control - Read/Write."
        textline "            "
        bitfld.long 0x00 20. " WKCN ,Wake on Connect Enable (WKCNNT_E) - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 21. " WKDC ,Wake on Disconnect Enable (WKDSCNNT_E) - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 22. " WKOC ,Wake on Over-current Enable (WKOC_E) - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 23. " PHCD ,PHY Low Power Suspend - Clock Disable (PLPSCD) - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 24. " PFSC ,Port Force Full Speed Connect - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 25. " PTS_2 ,See description at bits 31-30" "0,1"
        textline "            "
        hexmask.long.byte 0x00 26.--28. 1. " PSPD ,Port Speed - Read Only."
        textline "            "
        bitfld.long 0x00 28. " PTW ,Parallel Transceiver Width This bit has no effect if serial interface engine is used." "0,1"
        textline "            "
        bitfld.long 0x00 29. " STS ,Serial Transceiver Select - Read Only Serial Transceiver Select 1 Serial Interface Engine is selected 0 Parallel Interface signals is selected Serial Interface Engine can be used in combination with UTMI+/ULPI physical interface to provide FS/LS signaling instead of the parallel interface signals." "0,1"
        textline "            "
        hexmask.long.byte 0x00 30.--32. 1. " PTS_1 ,Bit field {bit25, bit31, bit30}: ""000b"" UTMI/UTMI+ ""001b"" Reserved ""010b"" ULPI ""011b"" Serial/USB 1.1 PHY/IC-USB (FS Only) ""100b"" HSIC All USB port interface modes are listed in this field description, but not all are supported."
width 11.
group.long 0x3a4++0x3
    line.long 0x00 "UOG2_OTGSC,On-The-Go Status & control"
        bitfld.long 0x00 0. " VD ,VBUS_Discharge - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 1. " VC ,VBUS Charge - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 3. " OT ,OTG Termination - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 4. " DP ,Data Pulsing - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 5. " IDPU ,ID Pullup - Read/Write This bit provide control over the ID pull-up resister; 0 = off, 1 = on [default]." "0,1"
        textline "          "
        bitfld.long 0x00 8. " ID ,USB ID - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 9. " AVV ,A VBus Valid - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 10. " ASV ,A Session Valid - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 11. " BSV ,B Session Valid - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 12. " BSE ,B Session End - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 13. " _1MST ,1 millisecond timer toggle - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 14. " DPS ,Data Bus Pulsing Status - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 16. " IDIS ,USB ID Interrupt Status - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 17. " AVVIS ,A VBus Valid Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 18. " ASVIS ,A Session Valid Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 19. " BSVIS ,B Session Valid Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 20. " BSEIS ,B Session End Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 21. " _1MSS ,1 millisecond timer Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 22. " DPIS ,Data Pulse Interrupt Status - Read/Write to Clear." "0,1"
        textline "          "
        bitfld.long 0x00 24. " IDIE ,USB ID Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 25. " AVVIE ,A VBus Valid Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 26. " ASVIE ,A Session Valid Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 27. " BSVIE ,B Session Valid Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 28. " BSEIE ,B Session End Interrupt Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 29. " _1MSE ,1 millisecond timer Interrupt Enable - Read/Write" "0,1"
        textline "          "
        bitfld.long 0x00 30. " DPIE ,Data Pulse Interrupt Enable" "0,1"
width 13.
group.long 0x3a8++0x3
    line.long 0x00 "UOG2_USBMODE,USB Device Mode"
        hexmask.long.byte 0x00 0.--2. 1. " CM ,Controller Mode - R/WO."
        textline "            "
        bitfld.long 0x00 2. " ES ,Endian Select - Read/Write." "0,1"
        textline "            "
        bitfld.long 0x00 3. " SLOM ,Setup Lockout Mode." "0,1"
        textline "            "
        bitfld.long 0x00 4. " SDIS ,Stream Disable Mode." "0,1"
width 20.
group.long 0x3ac++0x3
    line.long 0x00 "UOG2_ENDPTSETUPSTAT,Endpoint Setup Status"
        hexmask.long.word 0x00 0.--16. 1. " ENDPTSETUPSTAT ,Setup Endpoint Status."
width 16.
group.long 0x3b0++0x3
    line.long 0x00 "UOG2_ENDPTPRIME,Endpoint Prime"
        hexmask.long.byte 0x00 0.--8. 1. " PERB ,Prime Endpoint Receive Buffer - R/WS."
        textline "               "
        hexmask.long.byte 0x00 16.--24. 1. " PETB ,Prime Endpoint Transmit Buffer - R/WS."
width 16.
group.long 0x3b4++0x3
    line.long 0x00 "UOG2_ENDPTFLUSH,Endpoint Flush"
        hexmask.long.byte 0x00 0.--8. 1. " FERB ,Flush Endpoint Receive Buffer - R/WS."
        textline "               "
        hexmask.long.byte 0x00 16.--24. 1. " FETB ,Flush Endpoint Transmit Buffer - R/WS."
width 15.
rgroup.long 0x3b8++0x3
    line.long 0x00 "UOG2_ENDPTSTAT,Endpoint Status"
        hexmask.long.byte 0x00 0.--8. 1. " ERBR ,Endpoint Receive Buffer Ready -- Read Only."
        textline "              "
        hexmask.long.byte 0x00 16.--24. 1. " ETBR ,Endpoint Transmit Buffer Ready -- Read Only."
width 19.
group.long 0x3bc++0x3
    line.long 0x00 "UOG2_ENDPTCOMPLETE,Endpoint Complete"
        hexmask.long.byte 0x00 0.--8. 1. " ERCE ,Endpoint Receive Complete Event - RW/C."
        textline "                  "
        hexmask.long.byte 0x00 16.--24. 1. " ETCE ,Endpoint Transmit Complete Event - R/WC."
width 16.
group.long 0x3c0++0x3
    line.long 0x00 "UOG2_ENDPTCTRL0,Endpoint Control0"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control Endpoint0 is fixed as a Control End Point."
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 1 Enabled Endpoint0 is always enabled." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK [Default] 1 End Point Stalled Software can write a one to this bit to force the endpoint to return a STALL handshake to the Host." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 - Control Endpoint0 is fixed as a Control End Point."
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 1 Enabled Endpoint0 is always enabled." "0,1"
width 16.
group.long 0x3c4++0x3
    line.long 0x00 "UOG2_ENDPTCTRL1,Endpoint Control 1"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x3c8++0x3
    line.long 0x00 "UOG2_ENDPTCTRL2,Endpoint Control 2"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x3cc++0x3
    line.long 0x00 "UOG2_ENDPTCTRL3,Endpoint Control 3"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x3d0++0x3
    line.long 0x00 "UOG2_ENDPTCTRL4,Endpoint Control 4"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x3d4++0x3
    line.long 0x00 "UOG2_ENDPTCTRL5,Endpoint Control 5"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x3d8++0x3
    line.long 0x00 "UOG2_ENDPTCTRL6,Endpoint Control 6"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 16.
group.long 0x3dc++0x3
    line.long 0x00 "UOG2_ENDPTCTRL7,Endpoint Control 7"
        bitfld.long 0x00 0. " RXS ,RX Endpoint Stall - Read/Write 0 End Point OK." "0,1"
        textline "               "
        bitfld.long 0x00 1. " RXD ,RX Endpoint Data Sink - Read/Write - TBD 0 Dual Port Memory Buffer/DMA Engine [Default] Should always be written as zero." "0,1"
        textline "               "
        hexmask.long.byte 0x00 2.--4. 1. " RXT ,RX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Reserved"
        textline "               "
        bitfld.long 0x00 5. " RXI ,RX Data Toggle Inhibit 0 Disabled [Default] 1 Enabled This bit is only used for test and should always be written as zero." "0,1"
        textline "               "
        bitfld.long 0x00 6. " RXR ,RX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the host and device." "0,1"
        textline "               "
        bitfld.long 0x00 7. " RXE ,RX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
        textline "               "
        bitfld.long 0x00 16. " TXS ,TX Endpoint Stall - Read/Write 0 End Point OK 1 End Point Stalled This bit is set automatically upon receipt of a SETUP request if this Endpoint is not configured as a Control Endpoint." "0,1"
        textline "               "
        bitfld.long 0x00 17. " TXD ,TX Endpoint Data Source - Read/Write 0 Dual Port Memory Buffer/DMA Engine [DEFAULT] Should always be written as 0." "0,1"
        textline "               "
        hexmask.long.byte 0x00 18.--20. 1. " TXT ,TX Endpoint Type - Read/Write 00 Control 01 Isochronous 10 Bulk 11 Interrupt"
        textline "               "
        bitfld.long 0x00 21. " TXI ,TX Data Toggle Inhibit 0 PID Sequencing Enabled." "0,1"
        textline "               "
        bitfld.long 0x00 22. " TXR ,TX Data Toggle Reset (WS) Write 1 - Reset PID Sequence Whenever a configuration event is received for this Endpoint, software must write a one to this bit in order to synchronize the data PID's between the Host and device." "0,1"
        textline "               "
        bitfld.long 0x00 23. " TXE ,TX Endpoint Enable 0 Disabled [Default] 1 Enabled An Endpoint should be enabled only after it has been configured." "0,1"
width 7.
rgroup.long 0x400++0x3
    line.long 0x00 "UH1_ID,Identification register"
        hexmask.long.byte 0x00 0.--6. 1. " ID ,Configuration number."
        textline "      "
        hexmask.long.byte 0x00 8.--14. 1. " NID ,Complement version of ID"
        textline "      "
        hexmask.long.byte 0x00 16.--24. 1. " REVISION ,Revision number of the controller core."
width 14.
rgroup.long 0x404++0x3
    line.long 0x00 "UH1_HWGENERAL,Hardware General"
        hexmask.long.byte 0x00 4.--6. 1. " PHYW ,Data width of the transciever connected to the controller core."
        textline "             "
        hexmask.long.byte 0x00 6.--9. 1. " PHYM ,Transciever type PHYM bit reset value: '0000b' for OTG controller core, '0100b' for Host-only controller core."
        textline "             "
        hexmask.long.byte 0x00 9.--11. 1. " SM ,Serial interface mode capability SM bit reset value is '00b'"
width 11.
rgroup.long 0x408++0x3
    line.long 0x00 "UH1_HWHOST,Host Hardware Parameters"
        bitfld.long 0x00 0. " HC ,Host Capable." "0,1"
        textline "          "
        hexmask.long.byte 0x00 1.--4. 1. " NPORT ,The Nmber of downstream ports supported by the host controller is (NPORT+1)."
width 12.
rgroup.long 0x410++0x3
    line.long 0x00 "UH1_HWTXBUF,TX Buffer Hardware Parameters"
        hexmask.long.byte 0x00 0.--8. 1. " TXBURST ,Default burst size for memory to TX buffer transfer."
        textline "           "
        hexmask.long.byte 0x00 16.--24. 1. " TXCHANADD ,TX FIFO Buffer size is: (2^TXCHANADD) * 4 Bytes."
width 12.
rgroup.long 0x414++0x3
    line.long 0x00 "UH1_HWRXBUF,RX Buffer Hardware Parameters"
        hexmask.long.byte 0x00 0.--8. 1. " RXBURST ,Default burst size for memory to RX buffer transfer."
        textline "           "
        hexmask.long.byte 0x00 8.--16. 1. " RXADD ,Buffer total size for all receive endpoints is (2^RXADD)."
width 15.
group.long 0x480++0x3
    line.long 0x00 "UH1_GPTIMER0LD,General Purpose Timer #0 Load"
        hexmask.long.long 0x00 0.--24. 1. " GPTLD ,General Purpose Timer Load Value These bit fields are loaded to GPTCNT bits when GPTRST bit is set '1b'."
width 17.
group.long 0x484++0x3
    line.long 0x00 "UH1_GPTIMER0CTRL,General Purpose Timer #0 Controller"
        hexmask.long.long 0x00 0.--24. 1. " GPTCNT ,General Purpose Timer Counter."
        textline "                "
        bitfld.long 0x00 24. " GPTMODE ,General Purpose Timer Mode In one shot mode, the timer will count down to zero, generate an interrupt, and stop until the counter is reset by software; In repeat mode, the timer will count down to zero, generate an interrupt and automatically reload the counter value from GPTLD bits to start again." "0,1"
        textline "                "
        bitfld.long 0x00 30. " GPTRST ,General Purpose Timer Reset" "0,1"
        textline "                "
        bitfld.long 0x00 31. " GPTRUN ,General Purpose Timer Run GPTCNT bits are not effected when setting or clearing this bit." "0,1"
width 15.
group.long 0x488++0x3
    line.long 0x00 "UH1_GPTIMER1LD,General Purpose Timer #1 Load"
        hexmask.long.long 0x00 0.--24. 1. " GPTLD ,General Purpose Timer Load Value These bit fields are loaded to GPTCNT bits when GPTRST bit is set '1b'."
width 17.
group.long 0x48c++0x3
    line.long 0x00 "UH1_GPTIMER1CTRL,General Purpose Timer #1 Controller"
        hexmask.long.long 0x00 0.--24. 1. " GPTCNT ,General Purpose Timer Counter."
        textline "                "
        bitfld.long 0x00 24. " GPTMODE ,General Purpose Timer Mode In one shot mode, the timer will count down to zero, generate an interrupt, and stop until the counter is reset by software." "0,1"
        textline "                "
        bitfld.long 0x00 30. " GPTRST ,General Purpose Timer Reset" "0,1"
        textline "                "
        bitfld.long 0x00 31. " GPTRUN ,General Purpose Timer Run GPTCNT bits are not effected when setting or clearing this bit." "0,1"
width 12.
group.long 0x490++0x3
    line.long 0x00 "UH1_SBUSCFG,System Bus Config"
        hexmask.long.byte 0x00 0.--3. 1. " AHBBRST ,AHB master interface Burst configuration These bits control AHB master transfer type sequence (or priority)."
width 14.
rgroup.byte 0x500++0x0
    line.byte 0x00 "UH1_CAPLENGTH,Capability Registers Length"
        hexmask.byte.byte 0x00 0.--8. 1. " CAPLENGTH ,These bits are used as an offset to add to register base to find the beginning of the Operational Register."
width 15.
rgroup.word 0x502++0x1
    line.word 0x00 "UH1_HCIVERSION,Host Controller Interface Version"
        hexmask.word.word 0x00 0.--16. 1. " HCIVERSION ,Host Controller Interface Version Number Default value is '10h', which means EHCI rev1.0."
width 14.
rgroup.long 0x504++0x3
    line.long 0x00 "UH1_HCSPARAMS,Host Controller Structural Parameters"
        hexmask.long.byte 0x00 0.--4. 1. " N_PORTS ,Number of downstream ports."
        textline "             "
        bitfld.long 0x00 4. " PPC ,Port Power Control This field indicates whether the host controller implementation includes port power control." "0,1"
        textline "             "
        hexmask.long.byte 0x00 8.--12. 1. " N_PCC ,Number of Ports per Companion Controller This field indicates the number of ports supported per internal Companion Controller."
        textline "             "
        hexmask.long.byte 0x00 12.--16. 1. " N_CC ,Number of Companion Controller (N_CC)."
        textline "             "
        bitfld.long 0x00 16. " PI ,Port Indicators (P INDICATOR) This bit indicates whether the ports support port indicator control." "0,1"
        textline "             "
        hexmask.long.byte 0x00 20.--24. 1. " N_PTT ,Number of Ports per Transaction Translator (N_PTT)."
        textline "             "
        hexmask.long.byte 0x00 24.--28. 1. " N_TT ,Number of Transaction Translators (N_TT)."
width 14.
rgroup.long 0x508++0x3
    line.long 0x00 "UH1_HCCPARAMS,Host Controller Capability Parameters"
        bitfld.long 0x00 0. " ADC ,64-bit Addressing Capability This bit is set '0b' in all controller core, no 64-bit addressing capability is supported." "0,1"
        textline "             "
        bitfld.long 0x00 1. " PFL ,Programmable Frame List Flag If this bit is set to zero, then the system software must use a frame list length of 1024 elements with this host controller." "0,1"
        textline "             "
        bitfld.long 0x00 2. " ASP ,Asynchronous Schedule Park Capability If this bit is set to a one, then the host controller supports the park feature for high-speed queue heads in the Asynchronous Schedule." "0,1"
        textline "             "
        hexmask.long.byte 0x00 4.--8. 1. " IST ,Isochronous Scheduling Threshold."
        textline "             "
        hexmask.long.byte 0x00 8.--16. 1. " EECP ,EHCI Extended Capabilities Pointer."
width 11.
group.long 0x540++0x3
    line.long 0x00 "UH1_USBCMD,USB Command Register"
        bitfld.long 0x00 0. " RS ,Run/Stop (RS) - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 1. " RST ,Controller Reset (RESET) - Read/Write." "0,1"
        textline "          "
        hexmask.long.byte 0x00 2.--4. 1. " FS_1 ,See description at bit 15"
        textline "          "
        bitfld.long 0x00 4. " PSE ,Periodic Schedule Enable- Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 5. " ASE ,Asynchronous Schedule Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 6. " IAA ,Interrupt on Async Advance Doorbell - Read/Write." "0,1"
        textline "          "
        hexmask.long.byte 0x00 8.--10. 1. " ASP ,Asynchronous Schedule Park Mode Count - Read/Write."
        textline "          "
        bitfld.long 0x00 11. " ASPE ,Asynchronous Schedule Park Mode Enable - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 13. " SUTW ,Setup TripWire - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 14. " ATDTW ,Add dTD TripWire - Read/Write." "0,1"
        textline "          "
        bitfld.long 0x00 15. " FS_2 ,See also bits 3-2 Frame List Size - (Read/Write or Read Only)." "0,1"
        textline "          "
        hexmask.long.byte 0x00 16.--24. 1. " ITC ,Interrupt Threshold Control -Read/Write."
width 11.
group.long 0x544++0x3
    line.long 0x00 "UH1_USBSTS,USB Status Register"
        bitfld.long 0x00 0. " UI ,USB Interrupt (USBINT) - R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 1. " UEI ,USB Error Interrupt (USBERRINT) - R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 2. " PCI ,Port Change Detect - R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 3. " FRI ,Frame List Rollover - R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 4. " SEI ,System Error- R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 5. " AAI ,Interrupt on Async Advance - R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 6. " URI ,USB Reset Received - R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 7. " SRI ,SOF Received - R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 8. " SLI ,DCSuspend - R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 10. " ULPII ,ULPI Interrupt - R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 12. " HCH ,HCHaIted - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 13. " RCL ,Reclamation - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 14. " PS ,Periodic Schedule Status - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 15. " AS ,Asynchronous Schedule Status - Read Only." "0,1"
        textline "          "
        bitfld.long 0x00 16. " NAKI ,NAK Interrupt Bit--RO." "0,1"
        textline "          "
        bitfld.long 0x00 24. " TI0 ,General Purpose Timer Interrupt 0(GPTINT0)--R/WC." "0,1"
        textline "          "
        bitfld.long 0x00 25. " TI1 ,General Purpose Timer Interrupt 1(GPTINT1)--R/WC." "0,1"
width 12.
group.long 0x548++0x3
    line.long 0x00 "UH1_USBINTR,Interrupt Enable Register"
        bitfld.long 0x00 0. " UE ,USB Interrupt Enalbe When this bit is one and the UI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 1. " UEE ,USB Error Interrupt Enable When this bit is one and the UEI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 2. " PCE ,Port Change Detect Interrupt Enable When this bit is one and the PCI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 3. " FRE ,Frame List Rollover Interrupt Enable When this bit is one and the FRI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 4. " SEE ,System Error Interrupt Enable When this bit is one and the SEI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 5. " AAE ,Async Advance Interrupt Enable When this bit is one and the AAI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 6. " URE ,USB Reset Interrupt Enable When this bit is one and the URI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 7. " SRE ,SOF Received Interrupt Enable When this bit is one and the SRI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 8. " SLE ,Sleep Interrupt Enable When this bit is one and the SLI bit in n_n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 10. " ULPIE ,ULPI Interrupt Enable When this bit is one and the UPLII bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 16. " NAKE ,NAK Interrupt Enable When this bit is one and the NAKI bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 18. " UAIE ,USB Host Asynchronous Interrupt Enable When this bit is one, and the UAI bit in the n_USBSTS register is one, host controller will issue an interrupt at the next interrupt threshold." "0,1"
        textline "           "
        bitfld.long 0x00 19. " UPIE ,USB Host Periodic Interrupt Enable When this bit is one, and the UPI bit in the n_USBSTS register is one, host controller will issue an interrupt at the next interrupt threshold." "0,1"
        textline "           "
        bitfld.long 0x00 24. " TIE0 ,General Purpose Timer #0 Interrupt Enable When this bit is one and the TI0 bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 25. " TIE1 ,General Purpose Timer #1 Interrupt Enable When this bit is one and the TI1 bit in n_USBSTS register is a one the controller will issue an interrupt." "0,1"
width 12.
group.long 0x54c++0x3
    line.long 0x00 "UH1_FRINDEX,USB Frame Index"
        hexmask.long.word 0x00 0.--14. 1. " FRINDEX ,Frame Index."
width 21.
group.long 0x554++0x3
    line.long 0x00 "UH1_PERIODICLISTBASE,Frame List Base Address"
        hexmask.long.long 0x00 12.--32. 1. " BASEADR ,Base Address (Low)."
width 18.
group.long 0x558++0x3
    line.long 0x00 "UH1_ASYNCLISTADDR,Next Asynch. Address"
        hexmask.long.long 0x00 5.--32. 1. " ASYBASE ,Link Pointer Low (LPL)."
width 14.
group.long 0x560++0x3
    line.long 0x00 "UH1_BURSTSIZE,Programmable Burst Size"
        hexmask.long.byte 0x00 0.--8. 1. " RXPBURST ,Programmable RX Burst Size."
        textline "             "
        hexmask.long.word 0x00 8.--17. 1. " TXPBURST ,Programmable TX Burst Size."
width 17.
group.long 0x564++0x3
    line.long 0x00 "UH1_TXFILLTUNING,TX FIFO Fill Tuning"
        hexmask.long.byte 0x00 0.--8. 1. " TXSCHOH ,Scheduler Overhead."
        textline "                "
        hexmask.long.byte 0x00 8.--13. 1. " TXSCHHEALTH ,Scheduler Health Counter."
        textline "                "
        hexmask.long.byte 0x00 16.--22. 1. " TXFIFOTHRES ,FIFO Burst Threshold."
width 15.
group.long 0x580++0x3
    line.long 0x00 "UH1_CONFIGFLAG,Configure Flag Register"
        bitfld.long 0x00 0. " CF ,Configure Flag Host software sets this bit as the last action in its process of configuring the Host Controller." "0,1"
width 12.
group.long 0x584++0x3
    line.long 0x00 "UH1_PORTSC1,Port Status & Control"
        bitfld.long 0x00 0. " CCS ,Current Connect Status-Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 1. " CSC ,Connect Status Change-R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 2. " PE ,Port Enabled/Disabled-Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 3. " PEC ,Port Enable/Disable Change-R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 4. " OCA ,Over-current Active-Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 5. " OCC ,Over-current Change-R/WC." "0,1"
        textline "           "
        bitfld.long 0x00 6. " FPR ,Force Port Resume -Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 7. " SUSP ,Suspend - Read/Write or Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 8. " PR ,Port Reset - Read/Write or Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 9. " HSP ,High-Speed Port - Read Only." "0,1"
        textline "           "
        hexmask.long.byte 0x00 10.--12. 1. " LS ,Line Status-Read Only."
        textline "           "
        bitfld.long 0x00 12. " PP ,Port Power (PP)-Read/Write or Read Only." "0,1"
        textline "           "
        bitfld.long 0x00 13. " PO ,Port Owner-Read/Write." "0,1"
        textline "           "
        hexmask.long.byte 0x00 14.--16. 1. " PIC ,Port Indicator Control - Read/Write."
        textline "           "
        hexmask.long.byte 0x00 16.--20. 1. " PTC ,Port Test Control - Read/Write."
        textline "           "
        bitfld.long 0x00 20. " WKCN ,Wake on Connect Enable (WKCNNT_E) - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 21. " WKDC ,Wake on Disconnect Enable (WKDSCNNT_E) - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 22. " WKOC ,Wake on Over-current Enable (WKOC_E) - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 23. " PHCD ,PHY Low Power Suspend - Clock Disable (PLPSCD) - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 24. " PFSC ,Port Force Full Speed Connect - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 25. " PTS_2 ,See description at bits 31-30" "0,1"
        textline "           "
        hexmask.long.byte 0x00 26.--28. 1. " PSPD ,Port Speed - Read Only."
        textline "           "
        bitfld.long 0x00 28. " PTW ,Parallel Transceiver Width This bit has no effect if serial interface engine is used." "0,1"
        textline "           "
        bitfld.long 0x00 29. " STS ,Serial Transceiver Select - Read Only Serial Transceiver Select 1 Serial Interface Engine is selected 0 Parallel Interface signals is selected Serial Interface Engine can be used in combination with UTMI+/ULPI physical interface to provide FS/LS signaling instead of the parallel interface signals." "0,1"
        textline "           "
        hexmask.long.byte 0x00 30.--32. 1. " PTS_1 ,Bit field {bit25, bit31, bit30}: ""000b"" UTMI/UTMI+ ""001b"" Reserved ""010b"" ULPI ""011b"" Serial/USB 1.1 PHY/IC-USB (FS Only) ""100b"" HSIC All USB port interface modes are listed in this field description, but not all are supported."
width 12.
group.long 0x5a8++0x3
    line.long 0x00 "UH1_USBMODE,USB Device Mode"
        hexmask.long.byte 0x00 0.--2. 1. " CM ,Controller Mode - R/WO."
        textline "           "
        bitfld.long 0x00 2. " ES ,Endian Select - Read/Write." "0,1"
        textline "           "
        bitfld.long 0x00 3. " SLOM ,Setup Lockout Mode." "0,1"
        textline "           "
        bitfld.long 0x00 4. " SDIS ,Stream Disable Mode." "0,1"


tree.end



;--------------------------------------------------------------------------------
; USBNC
;--------------------------------------------------------------------------------
tree "USBNC"
    base ad:0x02184000

width 14.
group.long 0x800++0x3
    line.long 0x00 "USB_OTG1_CTRL,USB OTG1 Control Register"
        bitfld.long 0x00 7. " OVER_CUR_DIS ,Disable OTG1 Overcurrent Detection" "0,1"
        textline "             "
        bitfld.long 0x00 8. " OVER_CUR_POL ,OTG1 Polarity of Overcurrent The polarity of OTG1 port overcurrent event" "0,1"
        textline "             "
        bitfld.long 0x00 9. " PWR_POL ,OTG1 Power Polarity This bit should be set according to PMIC Power Pin polarity." "0,1"
        textline "             "
        bitfld.long 0x00 10. " WIE ,OTG1 Wake-up Interrupt Enable This bit enables or disables the OTG1 wake-up interrupt." "0,1"
        textline "             "
        bitfld.long 0x00 14. " WKUP_SW_EN ,OTG1 Software Wake-up Enable" "0,1"
        textline "             "
        bitfld.long 0x00 15. " WKUP_SW ,OTG1 Software Wake-up" "0,1"
        textline "             "
        bitfld.long 0x00 16. " WKUP_ID_EN ,OTG1 Wake-up on ID change enable" "0,1"
        textline "             "
        bitfld.long 0x00 17. " WKUP_VBUS_EN ,OTG1 wake-up on VBUS change enable" "0,1"
        textline "             "
        bitfld.long 0x00 31. " WIR ,OTG1 Wake-up Interrupt Request This bit indicates that a wake-up interrupt request is received on the OTG1 port." "0,1"
width 14.
group.long 0x804++0x3
    line.long 0x00 "USB_OTG2_CTRL,USB OTG2 Control Register"
        bitfld.long 0x00 7. " OVER_CUR_DIS ,Disable OTG2 Overcurrent Detection" "0,1"
        textline "             "
        bitfld.long 0x00 8. " OVER_CUR_POL ,OTG2 Polarity of Overcurrent The polarity of OTG2 port overcurrent event" "0,1"
        textline "             "
        bitfld.long 0x00 9. " PWR_POL ,OTG2 Power Polarity This bit should be set according to PMIC Power Pin polarity." "0,1"
        textline "             "
        bitfld.long 0x00 10. " WIE ,OTG2 Wake-up Interrupt Enable This bit enables or disables the OTG2 wake-up interrupt." "0,1"
        textline "             "
        bitfld.long 0x00 14. " WKUP_SW_EN ,OTG2 Software Wake-up Enable" "0,1"
        textline "             "
        bitfld.long 0x00 15. " WKUP_SW ,OTG2 Software Wake-up" "0,1"
        textline "             "
        bitfld.long 0x00 16. " WKUP_ID_EN ,OTG2 Wake-up on ID change enable" "0,1"
        textline "             "
        bitfld.long 0x00 17. " WKUP_VBUS_EN ,OTG2 wake-up on VBUS change enable" "0,1"
        textline "             "
        bitfld.long 0x00 31. " WIR ,OTG2 Wake-up Interrupt Request This bit indicates that a wake-up interrupt request is received on the OTG port." "0,1"
width 12.
group.long 0x808++0x3
    line.long 0x00 "USB_UH_CTRL,USB Host Control Register"
        bitfld.long 0x00 10. " WIE ,Host Wake-up Interrupt Enable This bit enables or disables the Host wake-up interrupt." "0,1"
        textline "           "
        bitfld.long 0x00 11. " RESET ,Force Host UTMI PHY Reset This bit is used to force a reset to the UTMI PHY." "0,1"
        textline "           "
        bitfld.long 0x00 12. " SUSPENDM ,Force Host UTMI PHY Suspend This bit is used to put PHY into suspend mode." "0,1"
        textline "           "
        bitfld.long 0x00 13. " _480M_CLK_ON ,Force OTG UTMI PHY 480M clock output on when Host is not in suspend mode." "0,1"
        textline "           "
        bitfld.long 0x00 14. " WKUP_SW_EN ,Host Software Wake-up Enable" "0,1"
        textline "           "
        bitfld.long 0x00 15. " WKUP_SW ,Host Software Wake-up" "0,1"
        textline "           "
        bitfld.long 0x00 31. " WIR ,Host Wake-up Interrupt Request This bit indicates that a wake-up interrupt request is received on the Host port." "0,1"
width 17.
group.long 0x810++0x3
    line.long 0x00 "USB_UH_HSIC_CTRL,USB Host HSIC Control Register"
        bitfld.long 0x00 11. " HSIC_CLK_ON ,Force Host HSIC module 480M clock on, even when in Host is in suspend mode." "0,1"
        textline "                "
        bitfld.long 0x00 12. " HSIC_EN ,Host HSIC enable" "0,1"
        textline "                "
        bitfld.long 0x00 31. " CLK_VLD ,Indicating whether Host HSIC clock is valid." "0,1"
width 20.
group.long 0x818++0x3
    line.long 0x00 "USB_OTG1_PHY_CTRL_0,OTG1 UTMI PHY Control 0 Register"
        bitfld.long 0x00 31. " UTMI_CLK_VLD ,Indicating whether OTG1 UTMI PHY clock is valid" "0,1"
width 20.
group.long 0x81c++0x3
    line.long 0x00 "USB_OTG2_PHY_CTRL_0,OTG2 UTMI PHY Control 0 Register"
        bitfld.long 0x00 31. " UTMI_CLK_VLD ,Indicating whether OTG2 UTMI PHY clock is valid" "0,1"


tree.end



;--------------------------------------------------------------------------------
; USBPHY
;--------------------------------------------------------------------------------
tree.open "USBPHY"
    tree "USBPHY1"
        base ad:0x020c9000

width 4.
group.long 0x0++0x3
    line.long 0x00 "PWD,USB PHY Power-Down Register"
        bitfld.long 0x00 10. " TXPWDFS ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 11. " TXPWDIBIAS ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 12. " TXPWDV2I ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 17. " RXPWDENV ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 18. " RXPWD1PT1 ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 19. " RXPWDDIFF ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 20. " RXPWDRX ,0 = Normal operation." "0,1"
width 3.
group.long 0x10++0x3
    line.long 0x00 "TX,USB PHY Transmitter Control Register"
        hexmask.long.byte 0x00 0.--4. 1. " D_CAL ,Resistor Trimming Code: 0000 = 0.16% 0111 = Nominal 1111 = +25%"
        textline "  "
        hexmask.long.byte 0x00 8.--12. 1. " TXCAL45DN ,Decode to select a 45-Ohm resistance to the USB_DN output pin."
        textline "  "
        hexmask.long.byte 0x00 16.--20. 1. " TXCAL45DP ,Decode to select a 45-Ohm resistance to the USB_DP output pin."
        textline "  "
        hexmask.long.byte 0x00 26.--29. 1. " USBPHY_TX_EDGECTRL ,Controls the edge-rate of the current sensing transistors used in HS transmit."
width 3.
group.long 0x20++0x3
    line.long 0x00 "RX,USB PHY Receiver Control Register"
        hexmask.long.byte 0x00 0.--3. 1. " ENVADJ ,The ENVADJ field adjusts the trip point for the envelope detector."
        textline "  "
        hexmask.long.byte 0x00 4.--7. 1. " DISCONADJ ,The DISCONADJ field adjusts the trip point for the disconnect detector: 000 = Trip-Level Voltage is 0.57500 V 001 = Trip-Level Voltage is 0.56875 V 010 = Trip-Level Voltage is 0.58125 V 011 = Trip-Level Voltage is 0.58750 V 1XX = Reserved"
        textline "  "
        bitfld.long 0x00 22. " RXDBYPASS ,0 = Normal operation." "0,1"
width 5.
group.long 0x30++0x3
    line.long 0x00 "CTRL,USB PHY General Control Register"
        bitfld.long 0x00 0. " ENOTG_ID_CHG_IRQ ,Enable OTG_ID_CHG_IRQ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " ENHOSTDISCONDETECT ,For host mode, enables high-speed disconnect detector." "0,1"
        textline "    "
        bitfld.long 0x00 2. " ENIRQHOSTDISCON ,Enables interrupt for detection of disconnection to Device when in high-speed host mode." "0,1"
        textline "    "
        bitfld.long 0x00 3. " HOSTDISCONDETECT_IRQ ,Indicates that the device has disconnected in high-speed mode." "0,1"
        textline "    "
        bitfld.long 0x00 4. " ENDEVPLUGINDETECT ,For device mode, enables 200-KOhm pullups for detecting connectivity to the host." "0,1"
        textline "    "
        bitfld.long 0x00 5. " DEVPLUGIN_POLARITY ,For device mode, if this bit is cleared to 0, then it trips the interrupt if the device is plugged in." "0,1"
        textline "    "
        bitfld.long 0x00 6. " OTG_ID_CHG_IRQ ,OTG ID change interrupt." "0,1"
        textline "    "
        bitfld.long 0x00 7. " ENOTGIDDETECT ,Enables circuit to detect resistance of MiniAB ID pin." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RESUMEIRQSTICKY ,Set to 1 will make RESUME_IRQ bit a sticky bit until software clear it." "0,1"
        textline "    "
        bitfld.long 0x00 9. " ENIRQRESUMEDETECT ,Enables interrupt for detection of a non-J state on the USB line." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RESUME_IRQ ,Indicates that the host is sending a wake-up after suspend." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ENIRQDEVPLUGIN ,Enables interrupt for the detection of connectivity to the USB line." "0,1"
        textline "    "
        bitfld.long 0x00 12. " DEVPLUGIN_IRQ ,Indicates that the device is connected." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DATA_ON_LRADC ,Enables the LRADC to monitor USB_DP and USB_DM." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ENUTMILEVEL2 ,Enables UTMI+ Level2." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ENUTMILEVEL3 ,Enables UTMI+ Level3." "0,1"
        textline "    "
        bitfld.long 0x00 16. " ENIRQWAKEUP ,Enables interrupt for the wakeup events." "0,1"
        textline "    "
        bitfld.long 0x00 17. " WAKEUP_IRQ ,Indicates that there is a wakeup event." "0,1"
        textline "    "
        bitfld.long 0x00 19. " ENAUTOCLR_CLKGATE ,Enables the feature to auto-clear the CLKGATE bit if there is wakeup event while USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 20. " ENAUTOCLR_PHY_PWD ,Enables the feature to auto-clear the PWD register bits in USBPHYx_PWD if there is wakeup event while USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 21. " ENDPDMCHG_WKUP ,Enables the feature to wakeup USB if DP/DM is toggled when USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 22. " ENIDCHG_WKUP ,Enables the feature to wakeup USB if ID is toggled when USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 23. " ENVBUSCHG_WKUP ,Enables the feature to wakeup USB if VBUS is toggled when USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 24. " FSDLL_RST_EN ,Enables the feature to reset the FSDLL lock detection logic at the end of each TX packet." "0,1"
        textline "    "
        bitfld.long 0x00 27. " OTG_ID_VALUE ,Almost same as OTGID_STATUS in USBPHYx_STATUS Register." "0,1"
        textline "    "
        bitfld.long 0x00 28. " HOST_FORCE_LS_SE0 ,Forces the next FS packet that is transmitted to have a EOP with LS timing." "0,1"
        textline "    "
        bitfld.long 0x00 29. " UTMI_SUSPENDM ,Used by the PHY to indicate a powered-down state." "0,1"
        textline "    "
        bitfld.long 0x00 30. " CLKGATE ,Gate UTMI Clocks." "0,1"
        textline "    "
        bitfld.long 0x00 31. " SFTRST ,Writing a 1 to this bit will soft-reset the USBPHYx_PWD, USBPHYx_TX, USBPHYx_RX, and USBPHYx_CTRL registers." "0,1"
width 7.
group.long 0x40++0x3
    line.long 0x00 "STATUS,USB PHY Status Register"
        bitfld.long 0x00 3. " HOSTDISCONDETECT_STATUS ,Indicates that the device has disconnected while in high-speed host mode." "0,1"
        textline "      "
        bitfld.long 0x00 6. " DEVPLUGIN_STATUS ,Indicates that the device has been connected on the USB_DP and USB_DM lines." "0,1"
        textline "      "
        bitfld.long 0x00 8. " OTGID_STATUS ,Indicates the results of ID pin on MiniAB plug." "0,1"
        textline "      "
        bitfld.long 0x00 10. " RESUME_STATUS ,Indicates that the host is sending a wake-up after suspend and has triggered an interrupt." "0,1"
width 6.
group.long 0x50++0x3
    line.long 0x00 "DEBUG,USB PHY Debug Register"
        bitfld.long 0x00 0. " OTGIDPIOLOCK ,Once OTG ID from USBPHYx_STATUS_OTGID_STATUS, use this to hold the value." "0,1"
        textline "     "
        bitfld.long 0x00 1. " DEBUG_INTERFACE_HOLD ,Use holding registers to assist in timing for external UTMI interface." "0,1"
        textline "     "
        hexmask.long.byte 0x00 2.--4. 1. " HSTPULLDOWN ,Set bit 3 to 1 to pull down 15-KOhm on USB_DP line."
        textline "     "
        hexmask.long.byte 0x00 4.--6. 1. " ENHSTPULLDOWN ,Set bit 5 to 1 to override the control of the USB_DP 15-KOhm pulldown."
        textline "     "
        hexmask.long.byte 0x00 8.--12. 1. " TX2RXCOUNT ,Delay in between the end of transmit to the beginning of receive."
        textline "     "
        bitfld.long 0x00 12. " ENTX2RXCOUNT ,Set this bit to allow a countdown to transition in between TX and RX." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--21. 1. " SQUELCHRESETCOUNT ,Delay in between the detection of squelch to the reset of high-speed RX."
        textline "     "
        bitfld.long 0x00 24. " ENSQUELCHRESET ,Set bit to allow squelch to reset high-speed receive." "0,1"
        textline "     "
        hexmask.long.byte 0x00 25.--29. 1. " SQUELCHRESETLENGTH ,Duration of RESET in terms of the number of 480-MHz cycles."
        textline "     "
        bitfld.long 0x00 29. " HOST_RESUME_DEBUG ,Choose to trigger the host resume SE0 with HOST_FORCE_LS_SE0 = 0 or UTMI_SUSPEND = 1." "0,1"
        textline "     "
        bitfld.long 0x00 30. " CLKGATE ,Gate Test Clocks." "0,1"
width 14.
rgroup.long 0x60++0x3
    line.long 0x00 "DEBUG0_STATUS,UTMI Debug Status Register 0"
        hexmask.long.word 0x00 0.--16. 1. " LOOP_BACK_FAIL_COUNT ,Running count of the failed pseudo-random generator loopback."
        textline "             "
        hexmask.long.word 0x00 16.--26. 1. " UTMI_RXERROR_FAIL_COUNT ,Running count of the UTMI_RXERROR."
        textline "             "
        hexmask.long.byte 0x00 26.--32. 1. " SQUELCH_COUNT ,Running count of the squelch reset instead of normal end for HS RX."
width 7.
group.long 0x70++0x3
    line.long 0x00 "DEBUG1,UTMI Debug Status Register 1"
        hexmask.long.byte 0x00 13.--15. 1. " ENTAILADJVD ,Delay increment of the rise of squelch: 00 = Delay is nominal 01 = Delay is +20% 10 = Delay is -20% 11 = Delay is -40%"
width 8.
rgroup.long 0x80++0x3
    line.long 0x00 "VERSION,UTMI RTL Version"
        hexmask.long.word 0x00 0.--16. 1. " STEP ,Fixed read-only value reflecting the stepping of the RTL version."
        textline "       "
        hexmask.long.byte 0x00 16.--24. 1. " MINOR ,Fixed read-only value reflecting the MINOR field of the RTL version."
        textline "       "
        hexmask.long.byte 0x00 24.--32. 1. " MAJOR ,Fixed read-only value reflecting the MAJOR field of the RTL version."


    tree.end
    tree "USBPHY2"
        base ad:0x020ca000

width 4.
group.long 0x0++0x3
    line.long 0x00 "PWD,USB PHY Power-Down Register"
        bitfld.long 0x00 10. " TXPWDFS ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 11. " TXPWDIBIAS ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 12. " TXPWDV2I ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 17. " RXPWDENV ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 18. " RXPWD1PT1 ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 19. " RXPWDDIFF ,0 = Normal operation." "0,1"
        textline "   "
        bitfld.long 0x00 20. " RXPWDRX ,0 = Normal operation." "0,1"
width 3.
group.long 0x10++0x3
    line.long 0x00 "TX,USB PHY Transmitter Control Register"
        hexmask.long.byte 0x00 0.--4. 1. " D_CAL ,Resistor Trimming Code: 0000 = 0.16% 0111 = Nominal 1111 = +25%"
        textline "  "
        hexmask.long.byte 0x00 8.--12. 1. " TXCAL45DN ,Decode to select a 45-Ohm resistance to the USB_DN output pin."
        textline "  "
        hexmask.long.byte 0x00 16.--20. 1. " TXCAL45DP ,Decode to select a 45-Ohm resistance to the USB_DP output pin."
        textline "  "
        hexmask.long.byte 0x00 26.--29. 1. " USBPHY_TX_EDGECTRL ,Controls the edge-rate of the current sensing transistors used in HS transmit."
width 3.
group.long 0x20++0x3
    line.long 0x00 "RX,USB PHY Receiver Control Register"
        hexmask.long.byte 0x00 0.--3. 1. " ENVADJ ,The ENVADJ field adjusts the trip point for the envelope detector."
        textline "  "
        hexmask.long.byte 0x00 4.--7. 1. " DISCONADJ ,The DISCONADJ field adjusts the trip point for the disconnect detector: 000 = Trip-Level Voltage is 0.57500 V 001 = Trip-Level Voltage is 0.56875 V 010 = Trip-Level Voltage is 0.58125 V 011 = Trip-Level Voltage is 0.58750 V 1XX = Reserved"
        textline "  "
        bitfld.long 0x00 22. " RXDBYPASS ,0 = Normal operation." "0,1"
width 5.
group.long 0x30++0x3
    line.long 0x00 "CTRL,USB PHY General Control Register"
        bitfld.long 0x00 0. " ENOTG_ID_CHG_IRQ ,Enable OTG_ID_CHG_IRQ." "0,1"
        textline "    "
        bitfld.long 0x00 1. " ENHOSTDISCONDETECT ,For host mode, enables high-speed disconnect detector." "0,1"
        textline "    "
        bitfld.long 0x00 2. " ENIRQHOSTDISCON ,Enables interrupt for detection of disconnection to Device when in high-speed host mode." "0,1"
        textline "    "
        bitfld.long 0x00 3. " HOSTDISCONDETECT_IRQ ,Indicates that the device has disconnected in high-speed mode." "0,1"
        textline "    "
        bitfld.long 0x00 4. " ENDEVPLUGINDETECT ,For device mode, enables 200-KOhm pullups for detecting connectivity to the host." "0,1"
        textline "    "
        bitfld.long 0x00 5. " DEVPLUGIN_POLARITY ,For device mode, if this bit is cleared to 0, then it trips the interrupt if the device is plugged in." "0,1"
        textline "    "
        bitfld.long 0x00 6. " OTG_ID_CHG_IRQ ,OTG ID change interrupt." "0,1"
        textline "    "
        bitfld.long 0x00 7. " ENOTGIDDETECT ,Enables circuit to detect resistance of MiniAB ID pin." "0,1"
        textline "    "
        bitfld.long 0x00 8. " RESUMEIRQSTICKY ,Set to 1 will make RESUME_IRQ bit a sticky bit until software clear it." "0,1"
        textline "    "
        bitfld.long 0x00 9. " ENIRQRESUMEDETECT ,Enables interrupt for detection of a non-J state on the USB line." "0,1"
        textline "    "
        bitfld.long 0x00 10. " RESUME_IRQ ,Indicates that the host is sending a wake-up after suspend." "0,1"
        textline "    "
        bitfld.long 0x00 11. " ENIRQDEVPLUGIN ,Enables interrupt for the detection of connectivity to the USB line." "0,1"
        textline "    "
        bitfld.long 0x00 12. " DEVPLUGIN_IRQ ,Indicates that the device is connected." "0,1"
        textline "    "
        bitfld.long 0x00 13. " DATA_ON_LRADC ,Enables the LRADC to monitor USB_DP and USB_DM." "0,1"
        textline "    "
        bitfld.long 0x00 14. " ENUTMILEVEL2 ,Enables UTMI+ Level2." "0,1"
        textline "    "
        bitfld.long 0x00 15. " ENUTMILEVEL3 ,Enables UTMI+ Level3." "0,1"
        textline "    "
        bitfld.long 0x00 16. " ENIRQWAKEUP ,Enables interrupt for the wakeup events." "0,1"
        textline "    "
        bitfld.long 0x00 17. " WAKEUP_IRQ ,Indicates that there is a wakeup event." "0,1"
        textline "    "
        bitfld.long 0x00 19. " ENAUTOCLR_CLKGATE ,Enables the feature to auto-clear the CLKGATE bit if there is wakeup event while USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 20. " ENAUTOCLR_PHY_PWD ,Enables the feature to auto-clear the PWD register bits in USBPHYx_PWD if there is wakeup event while USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 21. " ENDPDMCHG_WKUP ,Enables the feature to wakeup USB if DP/DM is toggled when USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 22. " ENIDCHG_WKUP ,Enables the feature to wakeup USB if ID is toggled when USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 23. " ENVBUSCHG_WKUP ,Enables the feature to wakeup USB if VBUS is toggled when USB is suspended." "0,1"
        textline "    "
        bitfld.long 0x00 24. " FSDLL_RST_EN ,Enables the feature to reset the FSDLL lock detection logic at the end of each TX packet." "0,1"
        textline "    "
        bitfld.long 0x00 27. " OTG_ID_VALUE ,Almost same as OTGID_STATUS in USBPHYx_STATUS Register." "0,1"
        textline "    "
        bitfld.long 0x00 28. " HOST_FORCE_LS_SE0 ,Forces the next FS packet that is transmitted to have a EOP with LS timing." "0,1"
        textline "    "
        bitfld.long 0x00 29. " UTMI_SUSPENDM ,Used by the PHY to indicate a powered-down state." "0,1"
        textline "    "
        bitfld.long 0x00 30. " CLKGATE ,Gate UTMI Clocks." "0,1"
        textline "    "
        bitfld.long 0x00 31. " SFTRST ,Writing a 1 to this bit will soft-reset the USBPHYx_PWD, USBPHYx_TX, USBPHYx_RX, and USBPHYx_CTRL registers." "0,1"
width 7.
group.long 0x40++0x3
    line.long 0x00 "STATUS,USB PHY Status Register"
        bitfld.long 0x00 3. " HOSTDISCONDETECT_STATUS ,Indicates that the device has disconnected while in high-speed host mode." "0,1"
        textline "      "
        bitfld.long 0x00 6. " DEVPLUGIN_STATUS ,Indicates that the device has been connected on the USB_DP and USB_DM lines." "0,1"
        textline "      "
        bitfld.long 0x00 8. " OTGID_STATUS ,Indicates the results of ID pin on MiniAB plug." "0,1"
        textline "      "
        bitfld.long 0x00 10. " RESUME_STATUS ,Indicates that the host is sending a wake-up after suspend and has triggered an interrupt." "0,1"
width 6.
group.long 0x50++0x3
    line.long 0x00 "DEBUG,USB PHY Debug Register"
        bitfld.long 0x00 0. " OTGIDPIOLOCK ,Once OTG ID from USBPHYx_STATUS_OTGID_STATUS, use this to hold the value." "0,1"
        textline "     "
        bitfld.long 0x00 1. " DEBUG_INTERFACE_HOLD ,Use holding registers to assist in timing for external UTMI interface." "0,1"
        textline "     "
        hexmask.long.byte 0x00 2.--4. 1. " HSTPULLDOWN ,Set bit 3 to 1 to pull down 15-KOhm on USB_DP line."
        textline "     "
        hexmask.long.byte 0x00 4.--6. 1. " ENHSTPULLDOWN ,Set bit 5 to 1 to override the control of the USB_DP 15-KOhm pulldown."
        textline "     "
        hexmask.long.byte 0x00 8.--12. 1. " TX2RXCOUNT ,Delay in between the end of transmit to the beginning of receive."
        textline "     "
        bitfld.long 0x00 12. " ENTX2RXCOUNT ,Set this bit to allow a countdown to transition in between TX and RX." "0,1"
        textline "     "
        hexmask.long.byte 0x00 16.--21. 1. " SQUELCHRESETCOUNT ,Delay in between the detection of squelch to the reset of high-speed RX."
        textline "     "
        bitfld.long 0x00 24. " ENSQUELCHRESET ,Set bit to allow squelch to reset high-speed receive." "0,1"
        textline "     "
        hexmask.long.byte 0x00 25.--29. 1. " SQUELCHRESETLENGTH ,Duration of RESET in terms of the number of 480-MHz cycles."
        textline "     "
        bitfld.long 0x00 29. " HOST_RESUME_DEBUG ,Choose to trigger the host resume SE0 with HOST_FORCE_LS_SE0 = 0 or UTMI_SUSPEND = 1." "0,1"
        textline "     "
        bitfld.long 0x00 30. " CLKGATE ,Gate Test Clocks." "0,1"
width 14.
rgroup.long 0x60++0x3
    line.long 0x00 "DEBUG0_STATUS,UTMI Debug Status Register 0"
        hexmask.long.word 0x00 0.--16. 1. " LOOP_BACK_FAIL_COUNT ,Running count of the failed pseudo-random generator loopback."
        textline "             "
        hexmask.long.word 0x00 16.--26. 1. " UTMI_RXERROR_FAIL_COUNT ,Running count of the UTMI_RXERROR."
        textline "             "
        hexmask.long.byte 0x00 26.--32. 1. " SQUELCH_COUNT ,Running count of the squelch reset instead of normal end for HS RX."
width 7.
group.long 0x70++0x3
    line.long 0x00 "DEBUG1,UTMI Debug Status Register 1"
        hexmask.long.byte 0x00 13.--15. 1. " ENTAILADJVD ,Delay increment of the rise of squelch: 00 = Delay is nominal 01 = Delay is +20% 10 = Delay is -20% 11 = Delay is -40%"
width 8.
rgroup.long 0x80++0x3
    line.long 0x00 "VERSION,UTMI RTL Version"
        hexmask.long.word 0x00 0.--16. 1. " STEP ,Fixed read-only value reflecting the stepping of the RTL version."
        textline "       "
        hexmask.long.byte 0x00 16.--24. 1. " MINOR ,Fixed read-only value reflecting the MINOR field of the RTL version."
        textline "       "
        hexmask.long.byte 0x00 24.--32. 1. " MAJOR ,Fixed read-only value reflecting the MAJOR field of the RTL version."


    tree.end

tree.end



;--------------------------------------------------------------------------------
; USDHC
;--------------------------------------------------------------------------------
tree.open "USDHC"
    tree "USDHC1"
        base ad:0x02190000

width 8.
group.long 0x0++0x3
    line.long 0x00 "DS_ADDR,DMA System Address"
        hexmask.long.long 0x00 2.--32. 1. " DS_ADDR ,DMA System Address: This register contains the 32-bit system memory address for a DMA transfer."
width 8.
group.long 0x4++0x3
    line.long 0x00 "BLK_ATT,Block Attributes"
        hexmask.long.word 0x00 0.--13. 1. " BLKSIZE ,Transfer Block Size: This register specifies the block size for block data transfers."
        textline "       "
        hexmask.long.word 0x00 16.--32. 1. " BLKCNT ,Blocks Count For Current Transfer: This register is enabled when the Block Count Enable bit in the Transfer Mode register is set to 1 and is valid only for multiple block transfers."
width 8.
group.long 0x8++0x3
    line.long 0x00 "CMD_ARG,Command Argument"
        hexmask.long.long 0x00 0.--32. 1. " CMDARG ,Command Argument: The SD/MMC Command Argument is specified as bits 39-8 of the Command Format in the SD or MMC Specification.This register is write protected when the Command Inhibit (CMD) bit in the Present State register is set."
width 12.
group.long 0xc++0x3
    line.long 0x00 "CMD_XFR_TYP,Command Transfer Type"
        hexmask.long.byte 0x00 16.--18. 1. " RSPTYP ,Response Type Select:"
        textline "           "
        bitfld.long 0x00 19. " CCCEN ,Command CRC Check Enable: If this bit is set to 1, the uSDHC shall check the CRC field in the response." "0,1"
        textline "           "
        bitfld.long 0x00 20. " CICEN ,Command Index Check Enable: If this bit is set to 1, the uSDHC will check the Index field in the response to see if it has the same value as the command index." "0,1"
        textline "           "
        bitfld.long 0x00 21. " DPSEL ,Data Present Select: This bit is set to 1 to indicate that data is present and shall be transferred using the DAT line." "0,1"
        textline "           "
        hexmask.long.byte 0x00 22.--24. 1. " CMDTYP ,Command Type: There are three types of special commands: Suspend, Resume and Abort."
        textline "           "
        hexmask.long.byte 0x00 24.--30. 1. " CMDINX ,Command Index: These bits shall be set to the command number that is specified in bits 45-40 of the Command-Format in the SD Memory Card Physical Layer Specification and SDIO Card Specification."
width 9.
rgroup.long 0x10++0x3
    line.long 0x00 "CMD_RSP0,Command Response0"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP0 ,Command Response 0: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x14++0x3
    line.long 0x00 "CMD_RSP1,Command Response1"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP1 ,Command Response 1: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x18++0x3
    line.long 0x00 "CMD_RSP2,Command Response2"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP2 ,Command Response 2: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x1c++0x3
    line.long 0x00 "CMD_RSP3,Command Response3"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP3 ,Command Response 3: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 19.
group.long 0x20++0x3
    line.long 0x00 "DATA_BUFF_ACC_PORT,Data Buffer Access Port"
        hexmask.long.long 0x00 0.--32. 1. " DATCONT ,Data Content: The Buffer Data Port register is for 32-bit data access by the ARM platform or the external DMA."
width 11.
rgroup.long 0x24++0x3
    line.long 0x00 "PRES_STATE,Present State"
        bitfld.long 0x00 0. " CIHB ,Command Inhibit (CMD): If this status bit is 0, it indicates that the CMD line is not in use and the uSDHC can issue a SD/MMC Command using the CMD line." "0,1"
        textline "          "
        bitfld.long 0x00 1. " CDIHB ,Command Inhibit (DAT): This status bit is generated if either the DAT Line Active or the Read Transfer Active is set to 1." "0,1"
        textline "          "
        bitfld.long 0x00 2. " DLA ,Data Line Active This status bit indicates whether one of the DAT lines on the SD Bus is in use." "0,1"
        textline "          "
        bitfld.long 0x00 3. " SDSTB ,SD Clock Stable This status bit indicates that the internal card clock is stable." "0,1"
        textline "          "
        bitfld.long 0x00 4. " IPGOFF ,ipg_clk Gated Off Internally: This status bit indicates that the ipg_clk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 5. " HCKOFF ,hclk Gated Off Internally: This status bit indicates that the hclk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 6. " PEROFF ,ipg_perclk Gated Off Internally: This status bit indicates that the ipg_perclk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 7. " SDOFF ,SD Clock Gated Off Internally: This status bit indicates that the SD Clock is internally gated off, because of buffer over/under-run or read pause without read wait assertion, or the driver set FRC_SDCLK_ON bit is 0 to stop the SD clock in idle status." "0,1"
        textline "          "
        bitfld.long 0x00 8. " WTA ,Write Transfer Active: This status bit indicates a write transfer is active." "0,1"
        textline "          "
        bitfld.long 0x00 9. " RTA ,Read Transfer Active: This status bit is used for detecting completion of a read transfer." "0,1"
        textline "          "
        bitfld.long 0x00 10. " BWEN ,Buffer Write Enable: This status bit is used for non-DMA write transfers." "0,1"
        textline "          "
        bitfld.long 0x00 11. " BREN ,Buffer Read Enable: This status bit is used for non-DMA read transfers." "0,1"
        textline "          "
        bitfld.long 0x00 12. " RTR ,Re-Tuning Request: (only for SD3.0 SDR104 mode) Host Controller may request Host Driver to execute re-tuning sequence by setting this bit when the data window is shifted by temperature drift and a tuned sampling point does not have a good margin to receive correct data." "0,1"
        textline "          "
        bitfld.long 0x00 15. " TSCD ,Tape Select Change Done : This bit indicates the dealy setting is effective after write CLK_TUNE_CTRL_STATUS register." "0,1"
        textline "          "
        bitfld.long 0x00 16. " CINST ,Card Inserted: This bit indicates whether a card has been inserted." "0,1"
        textline "          "
        bitfld.long 0x00 18. " CDPL ,Card Detect Pin Level: This bit reflects the inverse value of the CD# pin for the card socket." "0,1"
        textline "          "
        bitfld.long 0x00 19. " WPSPL ,Write Protect Switch Pin Level: The Write Protect Switch is supported for memory and combo cards.This bit reflects the inverted value of the WP pin of the card socket." "0,1"
        textline "          "
        bitfld.long 0x00 23. " CLSL ,CMD Line Signal Level: This status is used to check the CMD line level to recover from errors, and for debugging." "0,1"
        textline "          "
        hexmask.long.byte 0x00 24.--32. 1. " DLSL ,DAT[7:0] Line Signal Level: This status is used to check the DAT line level to recover from errors, and for debugging.This is especially useful in detecting the busy signal level from DAT[0]."
width 10.
group.long 0x28++0x3
    line.long 0x00 "PROT_CTRL,Protocol Control"
        bitfld.long 0x00 0. " LCTL ,LED Control: This bit, fully controlled by the Host Driver, is used to caution the user not to remove the card while the card is being accessed." "0,1"
        textline "         "
        hexmask.long.byte 0x00 1.--3. 1. " DTW ,Data Transfer Width: This bit selects the data width of the SD bus for a data transfer."
        textline "         "
        bitfld.long 0x00 3. " D3CD ,DAT3 as Card Detection Pin: If this bit is set, DAT3 should be pulled down to act as a card detection pin." "0,1"
        textline "         "
        hexmask.long.byte 0x00 4.--6. 1. " EMODE ,Endian Mode: The uSDHC supports all three endian modes in data transfer."
        textline "         "
        bitfld.long 0x00 6. " CDTL ,Card Detect Test Level: This is bit is enabled while the Card Detection Signal Selection is set to 1 and it indicates card insertion." "0,1"
        textline "         "
        bitfld.long 0x00 7. " CDSS ,Card Detect Signal Selection: This bit selects the source for the card detection." "0,1"
        textline "         "
        hexmask.long.byte 0x00 8.--10. 1. " DMASEL ,DMA Select: This field is valid while DMA (SDMA or ADMA) is enabled and selects the DMA operation."
        textline "         "
        bitfld.long 0x00 16. " SABGREQ ,Stop At Block Gap Request: This bit is used to stop executing a transaction at the next block gap for both DMA and non-DMA transfers." "0,1"
        textline "         "
        bitfld.long 0x00 17. " CREQ ,Continue Request: This bit is used to restart a transaction which was stopped using the Stop At Block Gap Request." "0,1"
        textline "         "
        bitfld.long 0x00 18. " RWCTL ,Read Wait Control: The read wait function is optional for SDIO cards." "0,1"
        textline "         "
        bitfld.long 0x00 19. " IABG ,Interrupt At Block Gap: This bit is valid only in 4-bit mode, of the SDIO card, and selects a sample point in the interrupt cycle." "0,1"
        textline "         "
        bitfld.long 0x00 20. " RD_DONE_NO_8CLK ,Read done no 8 clock: According to the SD/MMC spec, for read data transaction, 8 clocks are needed after the end bit of the last data block." "0,1"
        textline "         "
        bitfld.long 0x00 24. " WECINT ,Wakeup Event Enable On Card Interrupt: This bit enables a wakeup event, via a Card Interrupt, in the Interrupt Status register." "0,1"
        textline "         "
        bitfld.long 0x00 25. " WECINS ,Wakeup Event Enable On SD Card Insertion: This bit enables a wakeup event, via a Card Insertion, in the Interrupt Status register." "0,1"
        textline "         "
        bitfld.long 0x00 26. " WECRM ,Wakeup Event Enable On SD Card Removal: This bit enables a wakeup event, via a Card Removal, in the Interrupt Status register." "0,1"
        textline "         "
        hexmask.long.byte 0x00 27.--30. 1. " BURST_LEN_EN ,BURST length enable for INCR, INCR4/INCR8/INCR16, INCR4-WRAP/INCR8-WRAP/INCR16-WRAP This is used to enable/disable the burst length for the external AHB2AXI bridge."
        textline "         "
        bitfld.long 0x00 30. " NON_EXACT_BLK_RD ,Current block read is non-exact block read." "0,1"
width 9.
group.long 0x2c++0x3
    line.long 0x00 "SYS_CTRL,System Control"
        hexmask.long.byte 0x00 4.--8. 1. " DVS ,Divisor: This register is used to provide a more exact divisor to generate the desired SD clock frequency."
        textline "        "
        hexmask.long.byte 0x00 8.--16. 1. " SDCLKFS ,SDCLK Frequency Select: This register is used to select the frequency of the SDCLK pin."
        textline "        "
        hexmask.long.byte 0x00 16.--20. 1. " DTOCV ,Data Timeout Counter Value: This value determines the interval by which DAT line timeouts are detected."
        textline "        "
        bitfld.long 0x00 23. " IPP_RST_N ,This register's value will be output to CARD from pad directly for hardware reset of the card if the card supports this feature." "0,1"
        textline "        "
        bitfld.long 0x00 24. " RSTA ,Software Reset For ALL: This reset effects the entire Host Controller except for the card detection circuit." "0,1"
        textline "        "
        bitfld.long 0x00 25. " RSTC ,Software Reset For CMD Line: Only part of the command circuit is reset." "0,1"
        textline "        "
        bitfld.long 0x00 26. " RSTD ,Software Reset For DAT Line: Only part of the data circuit is reset." "0,1"
        textline "        "
        bitfld.long 0x00 27. " INITA ,Initialization Active: When this bit is set, 80 SD-Clocks are sent to the card." "0,1"
        textline "        "
        bitfld.long 0x00 28. " RSTT ,Reset Tuning: When set this bit to 1, it will reset tuning circuit." "0,1"
width 11.
group.long 0x30++0x3
    line.long 0x00 "INT_STATUS,Interrupt Status"
        bitfld.long 0x00 0. " CC ,Command Complete: This bit is set when you receive the end bit of the command response (except Auto CMD12)." "0,1"
        textline "          "
        bitfld.long 0x00 1. " TC ,Transfer Complete: This bit is set when a read or write transfer is completed." "0,1"
        textline "          "
        bitfld.long 0x00 2. " BGE ,Block Gap Event: If the Stop At Block Gap Request bit in the Protocol Control register is set, this bit is set when a read or write transaction is stopped at a block gap." "0,1"
        textline "          "
        bitfld.long 0x00 3. " DINT ,DMA Interrupt: Occurs only when the internal DMA finishes the data transfer successfully." "0,1"
        textline "          "
        bitfld.long 0x00 4. " BWR ,Buffer Write Ready: This status bit is set if the Buffer Write Enable bit, in the Present State register, changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 5. " BRR ,Buffer Read Ready: This status bit is set if the Buffer Read Enable bit, in the Present State register, changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 6. " CINS ,Card Insertion: This status bit is set if the Card Inserted bit in the Present State register changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 7. " CRM ,Card Removal: This status bit is set if the Card Inserted bit in the Present State register changes from 1 to 0." "0,1"
        textline "          "
        bitfld.long 0x00 8. " CINT ,Card Interrupt: This status bit is set when an interrupt signal is detected from the external card." "0,1"
        textline "          "
        bitfld.long 0x00 12. " RTE ,Re-Tuning Event: (only for SD3.0 SDR104 mode) This status is set if Re-Tuning Request in the Present State register changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 14. " TP ,Tuning Pass:(only for SD3.0 SDR104 mode) Current CMD19 transfer is done successfully." "0,1"
        textline "          "
        bitfld.long 0x00 16. " CTOE ,Command Timeout Error: Occurs only if no response is returned within 64 SDCLK cycles from the end bit of the command." "0,1"
        textline "          "
        bitfld.long 0x00 17. " CCE ,Command CRC Error: Command CRC Error is generated in two cases." "0,1"
        textline "          "
        bitfld.long 0x00 18. " CEBE ,Command End Bit Error: Occurs when detecting that the end bit of a command response is 0." "0,1"
        textline "          "
        bitfld.long 0x00 19. " CIE ,Command Index Error: Occurs if a Command Index error occurs in the command response." "0,1"
        textline "          "
        bitfld.long 0x00 20. " DTOE ,Data Timeout Error: Occurs when detecting one of following time-out conditions." "0,1"
        textline "          "
        bitfld.long 0x00 21. " DCE ,Data CRC Error: Occurs when detecting a CRC error when transferring read data, which uses the DAT line, or when detecting the Write CRC status having a value other than 010." "0,1"
        textline "          "
        bitfld.long 0x00 22. " DEBE ,Data End Bit Error: Occurs either when detecting 0 at the end bit position of read data, which uses the DAT line, or at the end bit position of the CRC." "0,1"
        textline "          "
        bitfld.long 0x00 24. " AC12E ,Auto CMD12 Error: Occurs when detecting that one of the bits in the Auto CMD12 Error Status register has changed from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 26. " TNE ,Tuning Error: (only for SD3.0 SDR104 mode) This bit is set when an unrecoverable error is detected in a tuning circuit." "0,1"
        textline "          "
        bitfld.long 0x00 28. " DMAE ,DMA Error: Occurs when an Internal DMA transfer has failed." "0,1"
width 14.
group.long 0x34++0x3
    line.long 0x00 "INT_STATUS_EN,Interrupt Status Enable"
        bitfld.long 0x00 0. " CCSEN ,Command Complete Status Enable: 1 Enabled 0 Masked" "0,1"
        textline "             "
        bitfld.long 0x00 1. " TCSEN ,Transfer Complete Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 2. " BGESEN ,Block Gap Event Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 3. " DINTSEN ,DMA Interrupt Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 4. " BWRSEN ,Buffer Write Ready Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 5. " BRRSEN ,Buffer Read Ready Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 6. " CINSSEN ,Card Insertion Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 7. " CRMSEN ,Card Removal Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 8. " CINTSEN ,Card Interrupt Status Enable: If this bit is set to 0, the uSDHC will clear the interrupt request to the System." "0,1"
        textline "             "
        bitfld.long 0x00 12. " RTESEN ,Re-Tuning Event Status Enable" "0,1"
        textline "             "
        bitfld.long 0x00 14. " TPSEN ,Tuning Pass Status Enable" "0,1"
        textline "             "
        bitfld.long 0x00 16. " CTOESEN ,Command Timeout Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 17. " CCESEN ,Command CRC Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 18. " CEBESEN ,Command End Bit Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 19. " CIESEN ,Command Index Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 20. " DTOESEN ,Data Timeout Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 21. " DCESEN ,Data CRC Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 22. " DEBESEN ,Data End Bit Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 24. " AC12ESEN ,Auto CMD12 Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 26. " TNESEN ,Tuning Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 28. " DMAESEN ,DMA Error Status Enable:" "0,1"
width 14.
group.long 0x38++0x3
    line.long 0x00 "INT_SIGNAL_EN,Interrupt Signal Enable"
        bitfld.long 0x00 0. " CCIEN ,Command Complete Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 1. " TCIEN ,Transfer Complete Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 2. " BGEIEN ,Block Gap Event Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 3. " DINTIEN ,DMA Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 4. " BWRIEN ,Buffer Write Ready Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 5. " BRRIEN ,Buffer Read Ready Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 6. " CINSIEN ,Card Insertion Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 7. " CRMIEN ,Card Removal Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 8. " CINTIEN ,Card Interrupt Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 12. " RTEIEN ,Re-Tuning Event Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 14. " TPIEN ,Tuning Pass Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 16. " CTOEIEN ,Command Timeout Error Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 17. " CCEIEN ,Command CRC Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 18. " CEBEIEN ,Command End Bit Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 19. " CIEIEN ,Command Index Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 20. " DTOEIEN ,Data Timeout Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 21. " DCEIEN ,Data CRC Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 22. " DEBEIEN ,Data End Bit Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 24. " AC12EIEN ,Auto CMD12 Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 26. " TNEIEN ,Tuning Error Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 28. " DMAEIEN ,DMA Error Interrupt Enable:" "0,1"
width 21.
rgroup.long 0x3c++0x3
    line.long 0x00 "AUTOCMD12_ERR_STATUS,Auto CMD12 Error Status"
        bitfld.long 0x00 0. " AC12NE ,Auto CMD12 Not Executed: If memory multiple block data transfer is not started, due to a command error, this bit is not set because it is not necessary to issue an Auto CMD12." "0,1"
        textline "                    "
        bitfld.long 0x00 1. " AC12TOE ,Auto CMD12 Timeout Error: Occurs if no response is returned within 64 SDCLK cycles from the end bit of the command." "0,1"
        textline "                    "
        bitfld.long 0x00 2. " AC12EBE ,Auto CMD12 End Bit Error: Occurs when detecting that the end bit of command response is 0 which should be 1." "0,1"
        textline "                    "
        bitfld.long 0x00 3. " AC12CE ,Auto CMD12 CRC Error: Occurs when detecting a CRC error in the command response." "0,1"
        textline "                    "
        bitfld.long 0x00 4. " AC12IE ,Auto CMD12 Index Error: Occurs if the Command Index error occurs in response to a command." "0,1"
        textline "                    "
        bitfld.long 0x00 7. " CNIBAC12E ,Command Not Issued By Auto CMD12 Error: Setting this bit to 1 means CMD_wo_DAT is not executed due to an Auto CMD12 Error (D04-D01) in this register." "0,1"
        textline "                    "
        bitfld.long 0x00 22. " EXECUTE_TUNING ,Execute Tuning: When std_tuning_en bit is set, this bit is used to start tuning procedure." "0,1"
        textline "                    "
        bitfld.long 0x00 23. " SMP_CLK_SEL ,Sample Clock Select: When std_tuning_en bit is set, this bit is used to select sampling clock to receive CMD and DAT." "0,1"
width 14.
rgroup.long 0x40++0x3
    line.long 0x00 "HOST_CTRL_CAP,Host Controller Capabilities"
        bitfld.long 0x00 0. " SDR50_SUPPORT ,SDR50 support: This bit indicates support of SDR50 mode." "0,1"
        textline "             "
        bitfld.long 0x00 1. " SDR104_SUPPORT ,SDR104 support: This bit indicates support of SDR104 mode." "0,1"
        textline "             "
        bitfld.long 0x00 2. " DDR50_SUPPORT ,DDR50 support: This bit indicates support of DDR50 mode." "0,1"
        textline "             "
        hexmask.long.byte 0x00 8.--12. 1. " TIME_COUNT_RETUNING ,Time counter for retuning: This bit indicates an initial value of the Retuning Timer for Re-Tuning Mode1 and 3.Setting to 0 disables Retuning Timer."
        textline "             "
        bitfld.long 0x00 13. " USE_TUNING_SDR50 ,Use Tuning for SDR50: This bit is set to 1." "0,1"
        textline "             "
        hexmask.long.byte 0x00 14.--16. 1. " RETUNING_MODE ,Retuning Mode: This bit selects retuning method."
        textline "             "
        hexmask.long.byte 0x00 16.--19. 1. " MBL ,Max Block Length: This value indicates the maximum block size that the Host Driver can read and write to the buffer in the uSDHC."
        textline "             "
        bitfld.long 0x00 20. " ADMAS ,ADMA Support: This bit indicates whether the uSDHC supports the ADMA feature." "0,1"
        textline "             "
        bitfld.long 0x00 21. " HSS ,High Speed Support: This bit indicates whether the uSDHC supports High Speed mode and the Host System can supply a SD Clock frequency from 25 MHz to 50 MHz." "0,1"
        textline "             "
        bitfld.long 0x00 22. " DMAS ,DMA Support: This bit indicates whether the uSDHC is capable of using the internal DMA to transfer data between system memory and the data buffer directly." "0,1"
        textline "             "
        bitfld.long 0x00 23. " SRS ,Suspend / Resume Support: This bit indicates whether the uSDHC supports Suspend / Resume functionality." "0,1"
        textline "             "
        bitfld.long 0x00 24. " VS33 ,Voltage Support 3.3V: This bit shall depend on the Host System ability." "0,1"
        textline "             "
        bitfld.long 0x00 25. " VS30 ,Voltage Support 3.0V: This bit shall depend on the Host System ability." "0,1"
        textline "             "
        bitfld.long 0x00 26. " VS18 ,Voltage Support 1.8V: This bit shall depend on the Host System ability." "0,1"
width 9.
group.long 0x44++0x3
    line.long 0x00 "WTMK_LVL,Watermark Level"
        hexmask.long.byte 0x00 0.--8. 1. " RD_WML ,Read Watermark Level: The number of words used as the watermark level (FIFO threshold) in a DMA read operation."
        textline "        "
        hexmask.long.byte 0x00 8.--13. 1. " RD_BRST_LEN ,Read Burst Length: Due to system restriction, the actual burst length may not exceed 16."
        textline "        "
        hexmask.long.byte 0x00 16.--24. 1. " WR_WML ,Write Watermark Level: The number of words used as the watermark level (FIFO threshold) in a DMA write operation."
        textline "        "
        hexmask.long.byte 0x00 24.--29. 1. " WR_BRST_LEN ,Write Burst Length: Due to system restriction, the actual burst length may not exceed 16."
width 9.
group.long 0x48++0x3
    line.long 0x00 "MIX_CTRL,Mixer Control"
        bitfld.long 0x00 0. " DMAEN ,DMA Enable: This bit enables DMA functionality." "0,1"
        textline "        "
        bitfld.long 0x00 1. " BCEN ,Block Count Enable: This bit is used to enable the Block Count register, which is only relevant for multiple block transfers." "0,1"
        textline "        "
        bitfld.long 0x00 2. " AC12EN ,Auto CMD12 Enable: Multiple block transfers for memory require a CMD12 to stop the transaction." "0,1"
        textline "        "
        bitfld.long 0x00 3. " DDR_EN ,Dual Data Rate mode selection" "0,1"
        textline "        "
        bitfld.long 0x00 4. " DTDSEL ,Data Transfer Direction Select: This bit defines the direction of DAT line data transfers." "0,1"
        textline "        "
        bitfld.long 0x00 5. " MSBSEL ,Multi / Single Block Select: This bit enables multiple block DAT line data transfers." "0,1"
        textline "        "
        bitfld.long 0x00 6. " NIBBLE_POS ,In DDR 4-bit mode nibble position indictation." "0,1"
        textline "        "
        bitfld.long 0x00 7. " AC23EN ,Auto CMD23 Enable When this bit is set to 1, the Host Controller issues a CMD23 automatically before issuing a command specified in the Command Register." "0,1"
        textline "        "
        bitfld.long 0x00 22. " EXE_TUNE ,Execute Tuning: (Only used for SD3.0, SDR104 mode) When std_tuning_en is 0, this bit is set to 1 to indicate the Host Driver is starting tuning procedure." "0,1"
        textline "        "
        bitfld.long 0x00 23. " SMP_CLK_SEL ,When std_tuning_en is 0, this bit is used to select Tuned clock or Fixed clock to sample data/cmd (Only used for SD3.0, SDR104 mode)" "0,1"
        textline "        "
        bitfld.long 0x00 24. " AUTO_TUNE_EN ,Auto tuning enable (Only used for SD3.0, SDR104 mode)" "0,1"
        textline "        "
        bitfld.long 0x00 25. " FBCLK_SEL ,Feedback clock source selection (Only used for SD3.0, SDR104 mode)" "0,1"
width 12.
wgroup.long 0x50++0x3
    line.long 0x00 "FORCE_EVENT,Force Event"
        bitfld.long 0x00 0. " FEVTAC12NE ,Force Event Auto Command 12 Not Executed: Forces the AC12NE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 1. " FEVTAC12TOE ,Force Event Auto Command 12 Time Out Error: Forces the AC12TOE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 2. " FEVTAC12CE ,Force Event Auto Command 12 CRC Error: Forces the AC12CE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 3. " FEVTAC12EBE ,Force Event Auto Command 12 End Bit Error: Forces the AC12EBE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 4. " FEVTAC12IE ,Force Event Auto Command 12 Index Error: Forces the AC12IE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 7. " FEVTCNIBAC12E ,Force Event Command Not Executed By Auto Command 12 Error: Forces the CNIBAC12E bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 16. " FEVTCTOE ,Force Event Command Time Out Error: Forces the CTOE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 17. " FEVTCCE ,Force Event Command CRC Error: Forces the CCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 18. " FEVTCEBE ,Force Event Command End Bit Error: Forces the CEBE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 19. " FEVTCIE ,Force Event Command Index Error: Forces the CCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 20. " FEVTDTOE ,Force Event Data Time Out Error: Force the DTOE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 21. " FEVTDCE ,Force Event Data CRC Error: Forces the DCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 22. " FEVTDEBE ,Force Event Data End Bit Error: Forces the DEBE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 24. " FEVTAC12E ,Force Event Auto Command 12 Error: Forces the AC12E bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 26. " FEVTTNE ,Force Tuning Error: Forces the TNE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 28. " FEVTDMAE ,Force Event DMA Error: Forces the DMAE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 31. " FEVTCINT ,Force Event Card Interrupt: Writing 1 to this bit generates a short low-level pulse on the internal DAT[1] line, as if a self clearing interrupt was received from the external card." "0,1"
width 16.
rgroup.long 0x54++0x3
    line.long 0x00 "ADMA_ERR_STATUS,ADMA Error Status Register"
        hexmask.long.byte 0x00 0.--2. 1. " ADMAES ,ADMA Error State (when ADMA Error is occurred.): This field indicates the state of the ADMA when an error has occurred during an ADMA data transfer."
        textline "               "
        bitfld.long 0x00 2. " ADMALME ,ADMA Length Mismatch Error: This error occurs in the following 2 cases: While the Block Count Enable is being set, the total data length specified by the Descriptor table is different from that specified by the Block Count and Block Length Total data length can not be divided by the block length" "0,1"
        textline "               "
        bitfld.long 0x00 3. " ADMADCE ,ADMA Descritor Error: This error occurs when invalid descriptor fetched by ADMA:" "0,1"
width 14.
group.long 0x58++0x3
    line.long 0x00 "ADMA_SYS_ADDR,ADMA System Address"
        hexmask.long.long 0x00 2.--32. 1. " ADS_ADDR ,ADMA System Address: This register holds the word address of the executing command in the Descriptor table."
width 9.
group.long 0x60++0x3
    line.long 0x00 "DLL_CTRL,DLL (Delay Line) Control"
        bitfld.long 0x00 0. " DLL_CTRL_ENABLE ,Set this bit to 1 to enable the DLL and delay chain; otherwise; set to 0 to bypasses DLL." "0,1"
        textline "        "
        bitfld.long 0x00 1. " DLL_CTRL_RESET ,Setting this bit to 1 force a reset on DLL." "0,1"
        textline "        "
        bitfld.long 0x00 2. " DLL_CTRL_SLV_FORCE_UPD ,Setting this bit to 1, forces the slave delay line to update to the DLL calibrated value immediately." "0,1"
        textline "        "
        hexmask.long.byte 0x00 3.--7. 1. " DLL_CTRL_SLV_DLY_TARGET0 ,The delay target for the uSDHC loopback read clock can be programmed in 1/16th increments of an ref_clock half-period."
        textline "        "
        bitfld.long 0x00 7. " DLL_CTRL_GATE_UPDATE ,Set this bit to 1 to prevent the DLL from updating (since when clock_in exists, glitches may appear during DLL updates)." "0,1"
        textline "        "
        bitfld.long 0x00 8. " DLL_CTRL_SLV_OVERRIDE ,Set this bit to 1 to Enable manual override for slave delay chain using SLV_OVERRIDE_VAL; to set 0 to disable manual override." "0,1"
        textline "        "
        hexmask.long.byte 0x00 9.--16. 1. " DLL_CTRL_SLV_OVERRIDE_VAL ,When SLV_OVERRIDE=1 This field is used to select 1 of 128 physical taps manually."
        textline "        "
        hexmask.long.byte 0x00 16.--19. 1. " DLL_CTRL_SLV_DLY_TARGET1 ,Refer to DLL_CTRL_SLV_DLY_TARGET0 below."
        textline "        "
        hexmask.long.byte 0x00 20.--28. 1. " DLL_CTRL_SLV_UPDATE_INT ,Slave delay line update interval."
        textline "        "
        hexmask.long.byte 0x00 28.--32. 1. " DLL_CTRL_REF_UPDATE_INT ,DLL control loop update interval."
width 11.
rgroup.long 0x64++0x3
    line.long 0x00 "DLL_STATUS,DLL Status"
        bitfld.long 0x00 0. " DLL_STS_SLV_LOCK ,Slave delay-line lock status." "0,1"
        textline "          "
        bitfld.long 0x00 1. " DLL_STS_REF_LOCK ,Reference DLL lock status." "0,1"
        textline "          "
        hexmask.long.byte 0x00 2.--9. 1. " DLL_STS_SLV_SEL ,Slave delay line select status."
        textline "          "
        hexmask.long.byte 0x00 9.--16. 1. " DLL_STS_REF_SEL ,Reference delay line select taps."
width 21.
group.long 0x68++0x3
    line.long 0x00 "CLK_TUNE_CTRL_STATUS,CLK Tuning Control and Status"
        hexmask.long.byte 0x00 0.--4. 1. " DLY_CELL_SET_POST ,Set the number of delay cells on the feedback clock between CLK_OUT and CLK_POST."
        textline "                    "
        hexmask.long.byte 0x00 4.--8. 1. " DLY_CELL_SET_OUT ,Set the number of delay cells on the feedback clock between CLK_PRE and CLK_OUT."
        textline "                    "
        hexmask.long.byte 0x00 8.--15. 1. " DLY_CELL_SET_PRE ,Set the number of delay cells on the feedback clock between the feedback clock and CLK_PRE."
        textline "                    "
        bitfld.long 0x00 15. " NXT_ERR ,NXT error which means the number of delay cells added on the feedback clock is too large." "0,1"
        textline "                    "
        hexmask.long.byte 0x00 16.--20. 1. " TAP_SEL_POST ,Reflect the number of delay cells added on the feedback clock between CLK_OUT and CLK_POST."
        textline "                    "
        hexmask.long.byte 0x00 20.--24. 1. " TAP_SEL_OUT ,Reflect the number of delay cells added on the feedback clock between CLK_PRE and CLK_OUT."
        textline "                    "
        hexmask.long.byte 0x00 24.--31. 1. " TAP_SEL_PRE ,Reflects the number of delay cells added on the feedback clock between the feedback clock and CLK_PRE."
        textline "                    "
        bitfld.long 0x00 31. " PRE_ERR ,PRE error which means the number of delay cells added on the feedback clock is too small." "0,1"
width 10.
group.long 0xc0++0x3
    line.long 0x00 "VEND_SPEC,Vendor Specific Register"
        bitfld.long 0x00 0. " EXT_DMA_EN ,External DMA Request Enable Enable the request to external DMA." "0,1"
        textline "         "
        bitfld.long 0x00 1. " VSELECT ,Voltage Selection Change the value of output signal VSELECT, to control the voltage on pads for external card." "0,1"
        textline "         "
        bitfld.long 0x00 2. " CONFLICT_CHK_EN ,It's not implemented in uSDHC IP." "0,1"
        textline "         "
        bitfld.long 0x00 3. " AC12_WR_CHKBUSY_EN ,Check busy enable after auto CMD12 for write data packet" "0,1"
        textline "         "
        bitfld.long 0x00 4. " DAT3_CD_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 5. " CD_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 6. " WP_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 7. " CLKONJ_IN_ABORT ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 8. " FRC_SDCLK_ON ,Force CLK output active:" "0,1"
        textline "         "
        bitfld.long 0x00 11. " IPG_CLK_SOFT_EN ,IPG_CLK software enable" "0,1"
        textline "         "
        bitfld.long 0x00 12. " HCLK_SOFT_EN ,Please note, hardware auto-enables the AHB clock when the internal DMA is enabled even if HCLK_SOFT_EN is 0." "0,1"
        textline "         "
        bitfld.long 0x00 13. " IPG_PERCLK_SOFT_EN ,ipg_perclk software enable" "0,1"
        textline "         "
        bitfld.long 0x00 14. " CARD_CLK_SOFT_EN ,card clock software enable" "0,1"
        textline "         "
        bitfld.long 0x00 15. " CRC_CHK_DIS ,CRC check disable" "0,1"
        textline "         "
        hexmask.long.byte 0x00 16.--24. 1. " INT_ST_VAL ,Internal State Value Internal state value, reflecting the corresponding state value selected by Debug Select field."
width 9.
group.long 0xc4++0x3
    line.long 0x00 "MMC_BOOT,MMC Boot Register"
        hexmask.long.byte 0x00 0.--4. 1. " DTOCV_ACK ,Boot ACK time out counter value."
        textline "        "
        bitfld.long 0x00 4. " BOOT_ACK ,Boot ack mode select." "0,1"
        textline "        "
        bitfld.long 0x00 5. " BOOT_MODE ,Boot mode select." "0,1"
        textline "        "
        bitfld.long 0x00 6. " BOOT_EN ,Boot mode enable." "0,1"
        textline "        "
        bitfld.long 0x00 7. " AUTO_SABG_EN ,During boot, enable auto stop at block gap function." "0,1"
        textline "        "
        bitfld.long 0x00 8. " DISABLE_TIME_OUT ,Please note, when this bit is set, there is no timeout check no matter whether boot_en is set or not." "0,1"
        textline "        "
        hexmask.long.word 0x00 16.--32. 1. " BOOT_BLK_CNT ,The value defines the Stop At Block Gap value of automatic mode."
width 11.
group.long 0xc8++0x3
    line.long 0x00 "VEND_SPEC2,Vendor Specific 2 Register"
        bitfld.long 0x00 0. " SDR104_TIMING_DIS ,Timeout counter test." "0,1"
        textline "          "
        bitfld.long 0x00 1. " SDR104_OE_DIS ,CMD_OE/DAT_OE logic generation test." "0,1"
        textline "          "
        bitfld.long 0x00 2. " SDR104_NSD_DIS ,Interrupt window after abort command is sent." "0,1"
        textline "          "
        bitfld.long 0x00 3. " CARD_INT_D3_TEST ,Card interrupt detection test." "0,1"
        textline "          "
        bitfld.long 0x00 4. " TUNING_8BIT_EN ,Enable the auto tuning circuit to check the DAT[7:0]." "0,1"
        textline "          "
        bitfld.long 0x00 5. " TUNING_1BIT_EN ,Enable the auto tuning circuit to check the DAT0 only." "0,1"
        textline "          "
        bitfld.long 0x00 6. " TUNING_CMD_EN ,Enable the auto tuning circuit to check the CMD line." "0,1"
        textline "          "
        bitfld.long 0x00 7. " CARD_INT_AUTO_CLR_DIS ,Disable the feature to clear the Card interrupt status bit when Card Interrupt status enable bit is cleared." "0,1"
width 12.
group.long 0xcc++0x3
    line.long 0x00 "TUNING_CTRL,Tuning Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " TUNING_START_TAP ,The start dealy cell point when send first CMD19 in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 8.--16. 1. " TUNING_COUNTER ,The MAX repeat CMD19 times in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 16.--19. 1. " TUNING_STEP ,The increasing delay cell step in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 20.--23. 1. " TUNING_WINDOW ,Select data window value for auto tuning"
        textline "           "
        bitfld.long 0x00 24. " STD_TUNING_EN ,Standard tuning circuit and procedure enable: This bit is used to enable standard tuning circuit and procedure." "0,1"


    tree.end
    tree "USDHC2"
        base ad:0x02194000

width 8.
group.long 0x0++0x3
    line.long 0x00 "DS_ADDR,DMA System Address"
        hexmask.long.long 0x00 2.--32. 1. " DS_ADDR ,DMA System Address: This register contains the 32-bit system memory address for a DMA transfer."
width 8.
group.long 0x4++0x3
    line.long 0x00 "BLK_ATT,Block Attributes"
        hexmask.long.word 0x00 0.--13. 1. " BLKSIZE ,Transfer Block Size: This register specifies the block size for block data transfers."
        textline "       "
        hexmask.long.word 0x00 16.--32. 1. " BLKCNT ,Blocks Count For Current Transfer: This register is enabled when the Block Count Enable bit in the Transfer Mode register is set to 1 and is valid only for multiple block transfers."
width 8.
group.long 0x8++0x3
    line.long 0x00 "CMD_ARG,Command Argument"
        hexmask.long.long 0x00 0.--32. 1. " CMDARG ,Command Argument: The SD/MMC Command Argument is specified as bits 39-8 of the Command Format in the SD or MMC Specification.This register is write protected when the Command Inhibit (CMD) bit in the Present State register is set."
width 12.
group.long 0xc++0x3
    line.long 0x00 "CMD_XFR_TYP,Command Transfer Type"
        hexmask.long.byte 0x00 16.--18. 1. " RSPTYP ,Response Type Select:"
        textline "           "
        bitfld.long 0x00 19. " CCCEN ,Command CRC Check Enable: If this bit is set to 1, the uSDHC shall check the CRC field in the response." "0,1"
        textline "           "
        bitfld.long 0x00 20. " CICEN ,Command Index Check Enable: If this bit is set to 1, the uSDHC will check the Index field in the response to see if it has the same value as the command index." "0,1"
        textline "           "
        bitfld.long 0x00 21. " DPSEL ,Data Present Select: This bit is set to 1 to indicate that data is present and shall be transferred using the DAT line." "0,1"
        textline "           "
        hexmask.long.byte 0x00 22.--24. 1. " CMDTYP ,Command Type: There are three types of special commands: Suspend, Resume and Abort."
        textline "           "
        hexmask.long.byte 0x00 24.--30. 1. " CMDINX ,Command Index: These bits shall be set to the command number that is specified in bits 45-40 of the Command-Format in the SD Memory Card Physical Layer Specification and SDIO Card Specification."
width 9.
rgroup.long 0x10++0x3
    line.long 0x00 "CMD_RSP0,Command Response0"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP0 ,Command Response 0: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x14++0x3
    line.long 0x00 "CMD_RSP1,Command Response1"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP1 ,Command Response 1: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x18++0x3
    line.long 0x00 "CMD_RSP2,Command Response2"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP2 ,Command Response 2: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x1c++0x3
    line.long 0x00 "CMD_RSP3,Command Response3"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP3 ,Command Response 3: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 19.
group.long 0x20++0x3
    line.long 0x00 "DATA_BUFF_ACC_PORT,Data Buffer Access Port"
        hexmask.long.long 0x00 0.--32. 1. " DATCONT ,Data Content: The Buffer Data Port register is for 32-bit data access by the ARM platform or the external DMA."
width 11.
rgroup.long 0x24++0x3
    line.long 0x00 "PRES_STATE,Present State"
        bitfld.long 0x00 0. " CIHB ,Command Inhibit (CMD): If this status bit is 0, it indicates that the CMD line is not in use and the uSDHC can issue a SD/MMC Command using the CMD line." "0,1"
        textline "          "
        bitfld.long 0x00 1. " CDIHB ,Command Inhibit (DAT): This status bit is generated if either the DAT Line Active or the Read Transfer Active is set to 1." "0,1"
        textline "          "
        bitfld.long 0x00 2. " DLA ,Data Line Active This status bit indicates whether one of the DAT lines on the SD Bus is in use." "0,1"
        textline "          "
        bitfld.long 0x00 3. " SDSTB ,SD Clock Stable This status bit indicates that the internal card clock is stable." "0,1"
        textline "          "
        bitfld.long 0x00 4. " IPGOFF ,ipg_clk Gated Off Internally: This status bit indicates that the ipg_clk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 5. " HCKOFF ,hclk Gated Off Internally: This status bit indicates that the hclk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 6. " PEROFF ,ipg_perclk Gated Off Internally: This status bit indicates that the ipg_perclk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 7. " SDOFF ,SD Clock Gated Off Internally: This status bit indicates that the SD Clock is internally gated off, because of buffer over/under-run or read pause without read wait assertion, or the driver set FRC_SDCLK_ON bit is 0 to stop the SD clock in idle status." "0,1"
        textline "          "
        bitfld.long 0x00 8. " WTA ,Write Transfer Active: This status bit indicates a write transfer is active." "0,1"
        textline "          "
        bitfld.long 0x00 9. " RTA ,Read Transfer Active: This status bit is used for detecting completion of a read transfer." "0,1"
        textline "          "
        bitfld.long 0x00 10. " BWEN ,Buffer Write Enable: This status bit is used for non-DMA write transfers." "0,1"
        textline "          "
        bitfld.long 0x00 11. " BREN ,Buffer Read Enable: This status bit is used for non-DMA read transfers." "0,1"
        textline "          "
        bitfld.long 0x00 12. " RTR ,Re-Tuning Request: (only for SD3.0 SDR104 mode) Host Controller may request Host Driver to execute re-tuning sequence by setting this bit when the data window is shifted by temperature drift and a tuned sampling point does not have a good margin to receive correct data." "0,1"
        textline "          "
        bitfld.long 0x00 15. " TSCD ,Tape Select Change Done : This bit indicates the dealy setting is effective after write CLK_TUNE_CTRL_STATUS register." "0,1"
        textline "          "
        bitfld.long 0x00 16. " CINST ,Card Inserted: This bit indicates whether a card has been inserted." "0,1"
        textline "          "
        bitfld.long 0x00 18. " CDPL ,Card Detect Pin Level: This bit reflects the inverse value of the CD# pin for the card socket." "0,1"
        textline "          "
        bitfld.long 0x00 19. " WPSPL ,Write Protect Switch Pin Level: The Write Protect Switch is supported for memory and combo cards.This bit reflects the inverted value of the WP pin of the card socket." "0,1"
        textline "          "
        bitfld.long 0x00 23. " CLSL ,CMD Line Signal Level: This status is used to check the CMD line level to recover from errors, and for debugging." "0,1"
        textline "          "
        hexmask.long.byte 0x00 24.--32. 1. " DLSL ,DAT[7:0] Line Signal Level: This status is used to check the DAT line level to recover from errors, and for debugging.This is especially useful in detecting the busy signal level from DAT[0]."
width 10.
group.long 0x28++0x3
    line.long 0x00 "PROT_CTRL,Protocol Control"
        bitfld.long 0x00 0. " LCTL ,LED Control: This bit, fully controlled by the Host Driver, is used to caution the user not to remove the card while the card is being accessed." "0,1"
        textline "         "
        hexmask.long.byte 0x00 1.--3. 1. " DTW ,Data Transfer Width: This bit selects the data width of the SD bus for a data transfer."
        textline "         "
        bitfld.long 0x00 3. " D3CD ,DAT3 as Card Detection Pin: If this bit is set, DAT3 should be pulled down to act as a card detection pin." "0,1"
        textline "         "
        hexmask.long.byte 0x00 4.--6. 1. " EMODE ,Endian Mode: The uSDHC supports all three endian modes in data transfer."
        textline "         "
        bitfld.long 0x00 6. " CDTL ,Card Detect Test Level: This is bit is enabled while the Card Detection Signal Selection is set to 1 and it indicates card insertion." "0,1"
        textline "         "
        bitfld.long 0x00 7. " CDSS ,Card Detect Signal Selection: This bit selects the source for the card detection." "0,1"
        textline "         "
        hexmask.long.byte 0x00 8.--10. 1. " DMASEL ,DMA Select: This field is valid while DMA (SDMA or ADMA) is enabled and selects the DMA operation."
        textline "         "
        bitfld.long 0x00 16. " SABGREQ ,Stop At Block Gap Request: This bit is used to stop executing a transaction at the next block gap for both DMA and non-DMA transfers." "0,1"
        textline "         "
        bitfld.long 0x00 17. " CREQ ,Continue Request: This bit is used to restart a transaction which was stopped using the Stop At Block Gap Request." "0,1"
        textline "         "
        bitfld.long 0x00 18. " RWCTL ,Read Wait Control: The read wait function is optional for SDIO cards." "0,1"
        textline "         "
        bitfld.long 0x00 19. " IABG ,Interrupt At Block Gap: This bit is valid only in 4-bit mode, of the SDIO card, and selects a sample point in the interrupt cycle." "0,1"
        textline "         "
        bitfld.long 0x00 20. " RD_DONE_NO_8CLK ,Read done no 8 clock: According to the SD/MMC spec, for read data transaction, 8 clocks are needed after the end bit of the last data block." "0,1"
        textline "         "
        bitfld.long 0x00 24. " WECINT ,Wakeup Event Enable On Card Interrupt: This bit enables a wakeup event, via a Card Interrupt, in the Interrupt Status register." "0,1"
        textline "         "
        bitfld.long 0x00 25. " WECINS ,Wakeup Event Enable On SD Card Insertion: This bit enables a wakeup event, via a Card Insertion, in the Interrupt Status register." "0,1"
        textline "         "
        bitfld.long 0x00 26. " WECRM ,Wakeup Event Enable On SD Card Removal: This bit enables a wakeup event, via a Card Removal, in the Interrupt Status register." "0,1"
        textline "         "
        hexmask.long.byte 0x00 27.--30. 1. " BURST_LEN_EN ,BURST length enable for INCR, INCR4/INCR8/INCR16, INCR4-WRAP/INCR8-WRAP/INCR16-WRAP This is used to enable/disable the burst length for the external AHB2AXI bridge."
        textline "         "
        bitfld.long 0x00 30. " NON_EXACT_BLK_RD ,Current block read is non-exact block read." "0,1"
width 9.
group.long 0x2c++0x3
    line.long 0x00 "SYS_CTRL,System Control"
        hexmask.long.byte 0x00 4.--8. 1. " DVS ,Divisor: This register is used to provide a more exact divisor to generate the desired SD clock frequency."
        textline "        "
        hexmask.long.byte 0x00 8.--16. 1. " SDCLKFS ,SDCLK Frequency Select: This register is used to select the frequency of the SDCLK pin."
        textline "        "
        hexmask.long.byte 0x00 16.--20. 1. " DTOCV ,Data Timeout Counter Value: This value determines the interval by which DAT line timeouts are detected."
        textline "        "
        bitfld.long 0x00 23. " IPP_RST_N ,This register's value will be output to CARD from pad directly for hardware reset of the card if the card supports this feature." "0,1"
        textline "        "
        bitfld.long 0x00 24. " RSTA ,Software Reset For ALL: This reset effects the entire Host Controller except for the card detection circuit." "0,1"
        textline "        "
        bitfld.long 0x00 25. " RSTC ,Software Reset For CMD Line: Only part of the command circuit is reset." "0,1"
        textline "        "
        bitfld.long 0x00 26. " RSTD ,Software Reset For DAT Line: Only part of the data circuit is reset." "0,1"
        textline "        "
        bitfld.long 0x00 27. " INITA ,Initialization Active: When this bit is set, 80 SD-Clocks are sent to the card." "0,1"
        textline "        "
        bitfld.long 0x00 28. " RSTT ,Reset Tuning: When set this bit to 1, it will reset tuning circuit." "0,1"
width 11.
group.long 0x30++0x3
    line.long 0x00 "INT_STATUS,Interrupt Status"
        bitfld.long 0x00 0. " CC ,Command Complete: This bit is set when you receive the end bit of the command response (except Auto CMD12)." "0,1"
        textline "          "
        bitfld.long 0x00 1. " TC ,Transfer Complete: This bit is set when a read or write transfer is completed." "0,1"
        textline "          "
        bitfld.long 0x00 2. " BGE ,Block Gap Event: If the Stop At Block Gap Request bit in the Protocol Control register is set, this bit is set when a read or write transaction is stopped at a block gap." "0,1"
        textline "          "
        bitfld.long 0x00 3. " DINT ,DMA Interrupt: Occurs only when the internal DMA finishes the data transfer successfully." "0,1"
        textline "          "
        bitfld.long 0x00 4. " BWR ,Buffer Write Ready: This status bit is set if the Buffer Write Enable bit, in the Present State register, changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 5. " BRR ,Buffer Read Ready: This status bit is set if the Buffer Read Enable bit, in the Present State register, changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 6. " CINS ,Card Insertion: This status bit is set if the Card Inserted bit in the Present State register changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 7. " CRM ,Card Removal: This status bit is set if the Card Inserted bit in the Present State register changes from 1 to 0." "0,1"
        textline "          "
        bitfld.long 0x00 8. " CINT ,Card Interrupt: This status bit is set when an interrupt signal is detected from the external card." "0,1"
        textline "          "
        bitfld.long 0x00 12. " RTE ,Re-Tuning Event: (only for SD3.0 SDR104 mode) This status is set if Re-Tuning Request in the Present State register changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 14. " TP ,Tuning Pass:(only for SD3.0 SDR104 mode) Current CMD19 transfer is done successfully." "0,1"
        textline "          "
        bitfld.long 0x00 16. " CTOE ,Command Timeout Error: Occurs only if no response is returned within 64 SDCLK cycles from the end bit of the command." "0,1"
        textline "          "
        bitfld.long 0x00 17. " CCE ,Command CRC Error: Command CRC Error is generated in two cases." "0,1"
        textline "          "
        bitfld.long 0x00 18. " CEBE ,Command End Bit Error: Occurs when detecting that the end bit of a command response is 0." "0,1"
        textline "          "
        bitfld.long 0x00 19. " CIE ,Command Index Error: Occurs if a Command Index error occurs in the command response." "0,1"
        textline "          "
        bitfld.long 0x00 20. " DTOE ,Data Timeout Error: Occurs when detecting one of following time-out conditions." "0,1"
        textline "          "
        bitfld.long 0x00 21. " DCE ,Data CRC Error: Occurs when detecting a CRC error when transferring read data, which uses the DAT line, or when detecting the Write CRC status having a value other than 010." "0,1"
        textline "          "
        bitfld.long 0x00 22. " DEBE ,Data End Bit Error: Occurs either when detecting 0 at the end bit position of read data, which uses the DAT line, or at the end bit position of the CRC." "0,1"
        textline "          "
        bitfld.long 0x00 24. " AC12E ,Auto CMD12 Error: Occurs when detecting that one of the bits in the Auto CMD12 Error Status register has changed from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 26. " TNE ,Tuning Error: (only for SD3.0 SDR104 mode) This bit is set when an unrecoverable error is detected in a tuning circuit." "0,1"
        textline "          "
        bitfld.long 0x00 28. " DMAE ,DMA Error: Occurs when an Internal DMA transfer has failed." "0,1"
width 14.
group.long 0x34++0x3
    line.long 0x00 "INT_STATUS_EN,Interrupt Status Enable"
        bitfld.long 0x00 0. " CCSEN ,Command Complete Status Enable: 1 Enabled 0 Masked" "0,1"
        textline "             "
        bitfld.long 0x00 1. " TCSEN ,Transfer Complete Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 2. " BGESEN ,Block Gap Event Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 3. " DINTSEN ,DMA Interrupt Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 4. " BWRSEN ,Buffer Write Ready Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 5. " BRRSEN ,Buffer Read Ready Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 6. " CINSSEN ,Card Insertion Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 7. " CRMSEN ,Card Removal Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 8. " CINTSEN ,Card Interrupt Status Enable: If this bit is set to 0, the uSDHC will clear the interrupt request to the System." "0,1"
        textline "             "
        bitfld.long 0x00 12. " RTESEN ,Re-Tuning Event Status Enable" "0,1"
        textline "             "
        bitfld.long 0x00 14. " TPSEN ,Tuning Pass Status Enable" "0,1"
        textline "             "
        bitfld.long 0x00 16. " CTOESEN ,Command Timeout Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 17. " CCESEN ,Command CRC Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 18. " CEBESEN ,Command End Bit Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 19. " CIESEN ,Command Index Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 20. " DTOESEN ,Data Timeout Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 21. " DCESEN ,Data CRC Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 22. " DEBESEN ,Data End Bit Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 24. " AC12ESEN ,Auto CMD12 Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 26. " TNESEN ,Tuning Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 28. " DMAESEN ,DMA Error Status Enable:" "0,1"
width 14.
group.long 0x38++0x3
    line.long 0x00 "INT_SIGNAL_EN,Interrupt Signal Enable"
        bitfld.long 0x00 0. " CCIEN ,Command Complete Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 1. " TCIEN ,Transfer Complete Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 2. " BGEIEN ,Block Gap Event Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 3. " DINTIEN ,DMA Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 4. " BWRIEN ,Buffer Write Ready Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 5. " BRRIEN ,Buffer Read Ready Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 6. " CINSIEN ,Card Insertion Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 7. " CRMIEN ,Card Removal Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 8. " CINTIEN ,Card Interrupt Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 12. " RTEIEN ,Re-Tuning Event Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 14. " TPIEN ,Tuning Pass Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 16. " CTOEIEN ,Command Timeout Error Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 17. " CCEIEN ,Command CRC Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 18. " CEBEIEN ,Command End Bit Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 19. " CIEIEN ,Command Index Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 20. " DTOEIEN ,Data Timeout Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 21. " DCEIEN ,Data CRC Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 22. " DEBEIEN ,Data End Bit Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 24. " AC12EIEN ,Auto CMD12 Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 26. " TNEIEN ,Tuning Error Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 28. " DMAEIEN ,DMA Error Interrupt Enable:" "0,1"
width 21.
rgroup.long 0x3c++0x3
    line.long 0x00 "AUTOCMD12_ERR_STATUS,Auto CMD12 Error Status"
        bitfld.long 0x00 0. " AC12NE ,Auto CMD12 Not Executed: If memory multiple block data transfer is not started, due to a command error, this bit is not set because it is not necessary to issue an Auto CMD12." "0,1"
        textline "                    "
        bitfld.long 0x00 1. " AC12TOE ,Auto CMD12 Timeout Error: Occurs if no response is returned within 64 SDCLK cycles from the end bit of the command." "0,1"
        textline "                    "
        bitfld.long 0x00 2. " AC12EBE ,Auto CMD12 End Bit Error: Occurs when detecting that the end bit of command response is 0 which should be 1." "0,1"
        textline "                    "
        bitfld.long 0x00 3. " AC12CE ,Auto CMD12 CRC Error: Occurs when detecting a CRC error in the command response." "0,1"
        textline "                    "
        bitfld.long 0x00 4. " AC12IE ,Auto CMD12 Index Error: Occurs if the Command Index error occurs in response to a command." "0,1"
        textline "                    "
        bitfld.long 0x00 7. " CNIBAC12E ,Command Not Issued By Auto CMD12 Error: Setting this bit to 1 means CMD_wo_DAT is not executed due to an Auto CMD12 Error (D04-D01) in this register." "0,1"
        textline "                    "
        bitfld.long 0x00 22. " EXECUTE_TUNING ,Execute Tuning: When std_tuning_en bit is set, this bit is used to start tuning procedure." "0,1"
        textline "                    "
        bitfld.long 0x00 23. " SMP_CLK_SEL ,Sample Clock Select: When std_tuning_en bit is set, this bit is used to select sampling clock to receive CMD and DAT." "0,1"
width 14.
rgroup.long 0x40++0x3
    line.long 0x00 "HOST_CTRL_CAP,Host Controller Capabilities"
        bitfld.long 0x00 0. " SDR50_SUPPORT ,SDR50 support: This bit indicates support of SDR50 mode." "0,1"
        textline "             "
        bitfld.long 0x00 1. " SDR104_SUPPORT ,SDR104 support: This bit indicates support of SDR104 mode." "0,1"
        textline "             "
        bitfld.long 0x00 2. " DDR50_SUPPORT ,DDR50 support: This bit indicates support of DDR50 mode." "0,1"
        textline "             "
        hexmask.long.byte 0x00 8.--12. 1. " TIME_COUNT_RETUNING ,Time counter for retuning: This bit indicates an initial value of the Retuning Timer for Re-Tuning Mode1 and 3.Setting to 0 disables Retuning Timer."
        textline "             "
        bitfld.long 0x00 13. " USE_TUNING_SDR50 ,Use Tuning for SDR50: This bit is set to 1." "0,1"
        textline "             "
        hexmask.long.byte 0x00 14.--16. 1. " RETUNING_MODE ,Retuning Mode: This bit selects retuning method."
        textline "             "
        hexmask.long.byte 0x00 16.--19. 1. " MBL ,Max Block Length: This value indicates the maximum block size that the Host Driver can read and write to the buffer in the uSDHC."
        textline "             "
        bitfld.long 0x00 20. " ADMAS ,ADMA Support: This bit indicates whether the uSDHC supports the ADMA feature." "0,1"
        textline "             "
        bitfld.long 0x00 21. " HSS ,High Speed Support: This bit indicates whether the uSDHC supports High Speed mode and the Host System can supply a SD Clock frequency from 25 MHz to 50 MHz." "0,1"
        textline "             "
        bitfld.long 0x00 22. " DMAS ,DMA Support: This bit indicates whether the uSDHC is capable of using the internal DMA to transfer data between system memory and the data buffer directly." "0,1"
        textline "             "
        bitfld.long 0x00 23. " SRS ,Suspend / Resume Support: This bit indicates whether the uSDHC supports Suspend / Resume functionality." "0,1"
        textline "             "
        bitfld.long 0x00 24. " VS33 ,Voltage Support 3.3V: This bit shall depend on the Host System ability." "0,1"
        textline "             "
        bitfld.long 0x00 25. " VS30 ,Voltage Support 3.0V: This bit shall depend on the Host System ability." "0,1"
        textline "             "
        bitfld.long 0x00 26. " VS18 ,Voltage Support 1.8V: This bit shall depend on the Host System ability." "0,1"
width 9.
group.long 0x44++0x3
    line.long 0x00 "WTMK_LVL,Watermark Level"
        hexmask.long.byte 0x00 0.--8. 1. " RD_WML ,Read Watermark Level: The number of words used as the watermark level (FIFO threshold) in a DMA read operation."
        textline "        "
        hexmask.long.byte 0x00 8.--13. 1. " RD_BRST_LEN ,Read Burst Length: Due to system restriction, the actual burst length may not exceed 16."
        textline "        "
        hexmask.long.byte 0x00 16.--24. 1. " WR_WML ,Write Watermark Level: The number of words used as the watermark level (FIFO threshold) in a DMA write operation."
        textline "        "
        hexmask.long.byte 0x00 24.--29. 1. " WR_BRST_LEN ,Write Burst Length: Due to system restriction, the actual burst length may not exceed 16."
width 9.
group.long 0x48++0x3
    line.long 0x00 "MIX_CTRL,Mixer Control"
        bitfld.long 0x00 0. " DMAEN ,DMA Enable: This bit enables DMA functionality." "0,1"
        textline "        "
        bitfld.long 0x00 1. " BCEN ,Block Count Enable: This bit is used to enable the Block Count register, which is only relevant for multiple block transfers." "0,1"
        textline "        "
        bitfld.long 0x00 2. " AC12EN ,Auto CMD12 Enable: Multiple block transfers for memory require a CMD12 to stop the transaction." "0,1"
        textline "        "
        bitfld.long 0x00 3. " DDR_EN ,Dual Data Rate mode selection" "0,1"
        textline "        "
        bitfld.long 0x00 4. " DTDSEL ,Data Transfer Direction Select: This bit defines the direction of DAT line data transfers." "0,1"
        textline "        "
        bitfld.long 0x00 5. " MSBSEL ,Multi / Single Block Select: This bit enables multiple block DAT line data transfers." "0,1"
        textline "        "
        bitfld.long 0x00 6. " NIBBLE_POS ,In DDR 4-bit mode nibble position indictation." "0,1"
        textline "        "
        bitfld.long 0x00 7. " AC23EN ,Auto CMD23 Enable When this bit is set to 1, the Host Controller issues a CMD23 automatically before issuing a command specified in the Command Register." "0,1"
        textline "        "
        bitfld.long 0x00 22. " EXE_TUNE ,Execute Tuning: (Only used for SD3.0, SDR104 mode) When std_tuning_en is 0, this bit is set to 1 to indicate the Host Driver is starting tuning procedure." "0,1"
        textline "        "
        bitfld.long 0x00 23. " SMP_CLK_SEL ,When std_tuning_en is 0, this bit is used to select Tuned clock or Fixed clock to sample data/cmd (Only used for SD3.0, SDR104 mode)" "0,1"
        textline "        "
        bitfld.long 0x00 24. " AUTO_TUNE_EN ,Auto tuning enable (Only used for SD3.0, SDR104 mode)" "0,1"
        textline "        "
        bitfld.long 0x00 25. " FBCLK_SEL ,Feedback clock source selection (Only used for SD3.0, SDR104 mode)" "0,1"
width 12.
wgroup.long 0x50++0x3
    line.long 0x00 "FORCE_EVENT,Force Event"
        bitfld.long 0x00 0. " FEVTAC12NE ,Force Event Auto Command 12 Not Executed: Forces the AC12NE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 1. " FEVTAC12TOE ,Force Event Auto Command 12 Time Out Error: Forces the AC12TOE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 2. " FEVTAC12CE ,Force Event Auto Command 12 CRC Error: Forces the AC12CE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 3. " FEVTAC12EBE ,Force Event Auto Command 12 End Bit Error: Forces the AC12EBE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 4. " FEVTAC12IE ,Force Event Auto Command 12 Index Error: Forces the AC12IE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 7. " FEVTCNIBAC12E ,Force Event Command Not Executed By Auto Command 12 Error: Forces the CNIBAC12E bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 16. " FEVTCTOE ,Force Event Command Time Out Error: Forces the CTOE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 17. " FEVTCCE ,Force Event Command CRC Error: Forces the CCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 18. " FEVTCEBE ,Force Event Command End Bit Error: Forces the CEBE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 19. " FEVTCIE ,Force Event Command Index Error: Forces the CCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 20. " FEVTDTOE ,Force Event Data Time Out Error: Force the DTOE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 21. " FEVTDCE ,Force Event Data CRC Error: Forces the DCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 22. " FEVTDEBE ,Force Event Data End Bit Error: Forces the DEBE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 24. " FEVTAC12E ,Force Event Auto Command 12 Error: Forces the AC12E bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 26. " FEVTTNE ,Force Tuning Error: Forces the TNE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 28. " FEVTDMAE ,Force Event DMA Error: Forces the DMAE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 31. " FEVTCINT ,Force Event Card Interrupt: Writing 1 to this bit generates a short low-level pulse on the internal DAT[1] line, as if a self clearing interrupt was received from the external card." "0,1"
width 16.
rgroup.long 0x54++0x3
    line.long 0x00 "ADMA_ERR_STATUS,ADMA Error Status Register"
        hexmask.long.byte 0x00 0.--2. 1. " ADMAES ,ADMA Error State (when ADMA Error is occurred.): This field indicates the state of the ADMA when an error has occurred during an ADMA data transfer."
        textline "               "
        bitfld.long 0x00 2. " ADMALME ,ADMA Length Mismatch Error: This error occurs in the following 2 cases: While the Block Count Enable is being set, the total data length specified by the Descriptor table is different from that specified by the Block Count and Block Length Total data length can not be divided by the block length" "0,1"
        textline "               "
        bitfld.long 0x00 3. " ADMADCE ,ADMA Descritor Error: This error occurs when invalid descriptor fetched by ADMA:" "0,1"
width 14.
group.long 0x58++0x3
    line.long 0x00 "ADMA_SYS_ADDR,ADMA System Address"
        hexmask.long.long 0x00 2.--32. 1. " ADS_ADDR ,ADMA System Address: This register holds the word address of the executing command in the Descriptor table."
width 9.
group.long 0x60++0x3
    line.long 0x00 "DLL_CTRL,DLL (Delay Line) Control"
        bitfld.long 0x00 0. " DLL_CTRL_ENABLE ,Set this bit to 1 to enable the DLL and delay chain; otherwise; set to 0 to bypasses DLL." "0,1"
        textline "        "
        bitfld.long 0x00 1. " DLL_CTRL_RESET ,Setting this bit to 1 force a reset on DLL." "0,1"
        textline "        "
        bitfld.long 0x00 2. " DLL_CTRL_SLV_FORCE_UPD ,Setting this bit to 1, forces the slave delay line to update to the DLL calibrated value immediately." "0,1"
        textline "        "
        hexmask.long.byte 0x00 3.--7. 1. " DLL_CTRL_SLV_DLY_TARGET0 ,The delay target for the uSDHC loopback read clock can be programmed in 1/16th increments of an ref_clock half-period."
        textline "        "
        bitfld.long 0x00 7. " DLL_CTRL_GATE_UPDATE ,Set this bit to 1 to prevent the DLL from updating (since when clock_in exists, glitches may appear during DLL updates)." "0,1"
        textline "        "
        bitfld.long 0x00 8. " DLL_CTRL_SLV_OVERRIDE ,Set this bit to 1 to Enable manual override for slave delay chain using SLV_OVERRIDE_VAL; to set 0 to disable manual override." "0,1"
        textline "        "
        hexmask.long.byte 0x00 9.--16. 1. " DLL_CTRL_SLV_OVERRIDE_VAL ,When SLV_OVERRIDE=1 This field is used to select 1 of 128 physical taps manually."
        textline "        "
        hexmask.long.byte 0x00 16.--19. 1. " DLL_CTRL_SLV_DLY_TARGET1 ,Refer to DLL_CTRL_SLV_DLY_TARGET0 below."
        textline "        "
        hexmask.long.byte 0x00 20.--28. 1. " DLL_CTRL_SLV_UPDATE_INT ,Slave delay line update interval."
        textline "        "
        hexmask.long.byte 0x00 28.--32. 1. " DLL_CTRL_REF_UPDATE_INT ,DLL control loop update interval."
width 11.
rgroup.long 0x64++0x3
    line.long 0x00 "DLL_STATUS,DLL Status"
        bitfld.long 0x00 0. " DLL_STS_SLV_LOCK ,Slave delay-line lock status." "0,1"
        textline "          "
        bitfld.long 0x00 1. " DLL_STS_REF_LOCK ,Reference DLL lock status." "0,1"
        textline "          "
        hexmask.long.byte 0x00 2.--9. 1. " DLL_STS_SLV_SEL ,Slave delay line select status."
        textline "          "
        hexmask.long.byte 0x00 9.--16. 1. " DLL_STS_REF_SEL ,Reference delay line select taps."
width 21.
group.long 0x68++0x3
    line.long 0x00 "CLK_TUNE_CTRL_STATUS,CLK Tuning Control and Status"
        hexmask.long.byte 0x00 0.--4. 1. " DLY_CELL_SET_POST ,Set the number of delay cells on the feedback clock between CLK_OUT and CLK_POST."
        textline "                    "
        hexmask.long.byte 0x00 4.--8. 1. " DLY_CELL_SET_OUT ,Set the number of delay cells on the feedback clock between CLK_PRE and CLK_OUT."
        textline "                    "
        hexmask.long.byte 0x00 8.--15. 1. " DLY_CELL_SET_PRE ,Set the number of delay cells on the feedback clock between the feedback clock and CLK_PRE."
        textline "                    "
        bitfld.long 0x00 15. " NXT_ERR ,NXT error which means the number of delay cells added on the feedback clock is too large." "0,1"
        textline "                    "
        hexmask.long.byte 0x00 16.--20. 1. " TAP_SEL_POST ,Reflect the number of delay cells added on the feedback clock between CLK_OUT and CLK_POST."
        textline "                    "
        hexmask.long.byte 0x00 20.--24. 1. " TAP_SEL_OUT ,Reflect the number of delay cells added on the feedback clock between CLK_PRE and CLK_OUT."
        textline "                    "
        hexmask.long.byte 0x00 24.--31. 1. " TAP_SEL_PRE ,Reflects the number of delay cells added on the feedback clock between the feedback clock and CLK_PRE."
        textline "                    "
        bitfld.long 0x00 31. " PRE_ERR ,PRE error which means the number of delay cells added on the feedback clock is too small." "0,1"
width 10.
group.long 0xc0++0x3
    line.long 0x00 "VEND_SPEC,Vendor Specific Register"
        bitfld.long 0x00 0. " EXT_DMA_EN ,External DMA Request Enable Enable the request to external DMA." "0,1"
        textline "         "
        bitfld.long 0x00 1. " VSELECT ,Voltage Selection Change the value of output signal VSELECT, to control the voltage on pads for external card." "0,1"
        textline "         "
        bitfld.long 0x00 2. " CONFLICT_CHK_EN ,It's not implemented in uSDHC IP." "0,1"
        textline "         "
        bitfld.long 0x00 3. " AC12_WR_CHKBUSY_EN ,Check busy enable after auto CMD12 for write data packet" "0,1"
        textline "         "
        bitfld.long 0x00 4. " DAT3_CD_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 5. " CD_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 6. " WP_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 7. " CLKONJ_IN_ABORT ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 8. " FRC_SDCLK_ON ,Force CLK output active:" "0,1"
        textline "         "
        bitfld.long 0x00 11. " IPG_CLK_SOFT_EN ,IPG_CLK software enable" "0,1"
        textline "         "
        bitfld.long 0x00 12. " HCLK_SOFT_EN ,Please note, hardware auto-enables the AHB clock when the internal DMA is enabled even if HCLK_SOFT_EN is 0." "0,1"
        textline "         "
        bitfld.long 0x00 13. " IPG_PERCLK_SOFT_EN ,ipg_perclk software enable" "0,1"
        textline "         "
        bitfld.long 0x00 14. " CARD_CLK_SOFT_EN ,card clock software enable" "0,1"
        textline "         "
        bitfld.long 0x00 15. " CRC_CHK_DIS ,CRC check disable" "0,1"
        textline "         "
        hexmask.long.byte 0x00 16.--24. 1. " INT_ST_VAL ,Internal State Value Internal state value, reflecting the corresponding state value selected by Debug Select field."
width 9.
group.long 0xc4++0x3
    line.long 0x00 "MMC_BOOT,MMC Boot Register"
        hexmask.long.byte 0x00 0.--4. 1. " DTOCV_ACK ,Boot ACK time out counter value."
        textline "        "
        bitfld.long 0x00 4. " BOOT_ACK ,Boot ack mode select." "0,1"
        textline "        "
        bitfld.long 0x00 5. " BOOT_MODE ,Boot mode select." "0,1"
        textline "        "
        bitfld.long 0x00 6. " BOOT_EN ,Boot mode enable." "0,1"
        textline "        "
        bitfld.long 0x00 7. " AUTO_SABG_EN ,During boot, enable auto stop at block gap function." "0,1"
        textline "        "
        bitfld.long 0x00 8. " DISABLE_TIME_OUT ,Please note, when this bit is set, there is no timeout check no matter whether boot_en is set or not." "0,1"
        textline "        "
        hexmask.long.word 0x00 16.--32. 1. " BOOT_BLK_CNT ,The value defines the Stop At Block Gap value of automatic mode."
width 11.
group.long 0xc8++0x3
    line.long 0x00 "VEND_SPEC2,Vendor Specific 2 Register"
        bitfld.long 0x00 0. " SDR104_TIMING_DIS ,Timeout counter test." "0,1"
        textline "          "
        bitfld.long 0x00 1. " SDR104_OE_DIS ,CMD_OE/DAT_OE logic generation test." "0,1"
        textline "          "
        bitfld.long 0x00 2. " SDR104_NSD_DIS ,Interrupt window after abort command is sent." "0,1"
        textline "          "
        bitfld.long 0x00 3. " CARD_INT_D3_TEST ,Card interrupt detection test." "0,1"
        textline "          "
        bitfld.long 0x00 4. " TUNING_8BIT_EN ,Enable the auto tuning circuit to check the DAT[7:0]." "0,1"
        textline "          "
        bitfld.long 0x00 5. " TUNING_1BIT_EN ,Enable the auto tuning circuit to check the DAT0 only." "0,1"
        textline "          "
        bitfld.long 0x00 6. " TUNING_CMD_EN ,Enable the auto tuning circuit to check the CMD line." "0,1"
        textline "          "
        bitfld.long 0x00 7. " CARD_INT_AUTO_CLR_DIS ,Disable the feature to clear the Card interrupt status bit when Card Interrupt status enable bit is cleared." "0,1"
width 12.
group.long 0xcc++0x3
    line.long 0x00 "TUNING_CTRL,Tuning Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " TUNING_START_TAP ,The start dealy cell point when send first CMD19 in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 8.--16. 1. " TUNING_COUNTER ,The MAX repeat CMD19 times in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 16.--19. 1. " TUNING_STEP ,The increasing delay cell step in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 20.--23. 1. " TUNING_WINDOW ,Select data window value for auto tuning"
        textline "           "
        bitfld.long 0x00 24. " STD_TUNING_EN ,Standard tuning circuit and procedure enable: This bit is used to enable standard tuning circuit and procedure." "0,1"


    tree.end
    tree "USDHC3"
        base ad:0x02198000

width 8.
group.long 0x0++0x3
    line.long 0x00 "DS_ADDR,DMA System Address"
        hexmask.long.long 0x00 2.--32. 1. " DS_ADDR ,DMA System Address: This register contains the 32-bit system memory address for a DMA transfer."
width 8.
group.long 0x4++0x3
    line.long 0x00 "BLK_ATT,Block Attributes"
        hexmask.long.word 0x00 0.--13. 1. " BLKSIZE ,Transfer Block Size: This register specifies the block size for block data transfers."
        textline "       "
        hexmask.long.word 0x00 16.--32. 1. " BLKCNT ,Blocks Count For Current Transfer: This register is enabled when the Block Count Enable bit in the Transfer Mode register is set to 1 and is valid only for multiple block transfers."
width 8.
group.long 0x8++0x3
    line.long 0x00 "CMD_ARG,Command Argument"
        hexmask.long.long 0x00 0.--32. 1. " CMDARG ,Command Argument: The SD/MMC Command Argument is specified as bits 39-8 of the Command Format in the SD or MMC Specification.This register is write protected when the Command Inhibit (CMD) bit in the Present State register is set."
width 12.
group.long 0xc++0x3
    line.long 0x00 "CMD_XFR_TYP,Command Transfer Type"
        hexmask.long.byte 0x00 16.--18. 1. " RSPTYP ,Response Type Select:"
        textline "           "
        bitfld.long 0x00 19. " CCCEN ,Command CRC Check Enable: If this bit is set to 1, the uSDHC shall check the CRC field in the response." "0,1"
        textline "           "
        bitfld.long 0x00 20. " CICEN ,Command Index Check Enable: If this bit is set to 1, the uSDHC will check the Index field in the response to see if it has the same value as the command index." "0,1"
        textline "           "
        bitfld.long 0x00 21. " DPSEL ,Data Present Select: This bit is set to 1 to indicate that data is present and shall be transferred using the DAT line." "0,1"
        textline "           "
        hexmask.long.byte 0x00 22.--24. 1. " CMDTYP ,Command Type: There are three types of special commands: Suspend, Resume and Abort."
        textline "           "
        hexmask.long.byte 0x00 24.--30. 1. " CMDINX ,Command Index: These bits shall be set to the command number that is specified in bits 45-40 of the Command-Format in the SD Memory Card Physical Layer Specification and SDIO Card Specification."
width 9.
rgroup.long 0x10++0x3
    line.long 0x00 "CMD_RSP0,Command Response0"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP0 ,Command Response 0: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x14++0x3
    line.long 0x00 "CMD_RSP1,Command Response1"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP1 ,Command Response 1: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x18++0x3
    line.long 0x00 "CMD_RSP2,Command Response2"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP2 ,Command Response 2: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x1c++0x3
    line.long 0x00 "CMD_RSP3,Command Response3"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP3 ,Command Response 3: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 19.
group.long 0x20++0x3
    line.long 0x00 "DATA_BUFF_ACC_PORT,Data Buffer Access Port"
        hexmask.long.long 0x00 0.--32. 1. " DATCONT ,Data Content: The Buffer Data Port register is for 32-bit data access by the ARM platform or the external DMA."
width 11.
rgroup.long 0x24++0x3
    line.long 0x00 "PRES_STATE,Present State"
        bitfld.long 0x00 0. " CIHB ,Command Inhibit (CMD): If this status bit is 0, it indicates that the CMD line is not in use and the uSDHC can issue a SD/MMC Command using the CMD line." "0,1"
        textline "          "
        bitfld.long 0x00 1. " CDIHB ,Command Inhibit (DAT): This status bit is generated if either the DAT Line Active or the Read Transfer Active is set to 1." "0,1"
        textline "          "
        bitfld.long 0x00 2. " DLA ,Data Line Active This status bit indicates whether one of the DAT lines on the SD Bus is in use." "0,1"
        textline "          "
        bitfld.long 0x00 3. " SDSTB ,SD Clock Stable This status bit indicates that the internal card clock is stable." "0,1"
        textline "          "
        bitfld.long 0x00 4. " IPGOFF ,ipg_clk Gated Off Internally: This status bit indicates that the ipg_clk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 5. " HCKOFF ,hclk Gated Off Internally: This status bit indicates that the hclk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 6. " PEROFF ,ipg_perclk Gated Off Internally: This status bit indicates that the ipg_perclk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 7. " SDOFF ,SD Clock Gated Off Internally: This status bit indicates that the SD Clock is internally gated off, because of buffer over/under-run or read pause without read wait assertion, or the driver set FRC_SDCLK_ON bit is 0 to stop the SD clock in idle status." "0,1"
        textline "          "
        bitfld.long 0x00 8. " WTA ,Write Transfer Active: This status bit indicates a write transfer is active." "0,1"
        textline "          "
        bitfld.long 0x00 9. " RTA ,Read Transfer Active: This status bit is used for detecting completion of a read transfer." "0,1"
        textline "          "
        bitfld.long 0x00 10. " BWEN ,Buffer Write Enable: This status bit is used for non-DMA write transfers." "0,1"
        textline "          "
        bitfld.long 0x00 11. " BREN ,Buffer Read Enable: This status bit is used for non-DMA read transfers." "0,1"
        textline "          "
        bitfld.long 0x00 12. " RTR ,Re-Tuning Request: (only for SD3.0 SDR104 mode) Host Controller may request Host Driver to execute re-tuning sequence by setting this bit when the data window is shifted by temperature drift and a tuned sampling point does not have a good margin to receive correct data." "0,1"
        textline "          "
        bitfld.long 0x00 15. " TSCD ,Tape Select Change Done : This bit indicates the dealy setting is effective after write CLK_TUNE_CTRL_STATUS register." "0,1"
        textline "          "
        bitfld.long 0x00 16. " CINST ,Card Inserted: This bit indicates whether a card has been inserted." "0,1"
        textline "          "
        bitfld.long 0x00 18. " CDPL ,Card Detect Pin Level: This bit reflects the inverse value of the CD# pin for the card socket." "0,1"
        textline "          "
        bitfld.long 0x00 19. " WPSPL ,Write Protect Switch Pin Level: The Write Protect Switch is supported for memory and combo cards.This bit reflects the inverted value of the WP pin of the card socket." "0,1"
        textline "          "
        bitfld.long 0x00 23. " CLSL ,CMD Line Signal Level: This status is used to check the CMD line level to recover from errors, and for debugging." "0,1"
        textline "          "
        hexmask.long.byte 0x00 24.--32. 1. " DLSL ,DAT[7:0] Line Signal Level: This status is used to check the DAT line level to recover from errors, and for debugging.This is especially useful in detecting the busy signal level from DAT[0]."
width 10.
group.long 0x28++0x3
    line.long 0x00 "PROT_CTRL,Protocol Control"
        bitfld.long 0x00 0. " LCTL ,LED Control: This bit, fully controlled by the Host Driver, is used to caution the user not to remove the card while the card is being accessed." "0,1"
        textline "         "
        hexmask.long.byte 0x00 1.--3. 1. " DTW ,Data Transfer Width: This bit selects the data width of the SD bus for a data transfer."
        textline "         "
        bitfld.long 0x00 3. " D3CD ,DAT3 as Card Detection Pin: If this bit is set, DAT3 should be pulled down to act as a card detection pin." "0,1"
        textline "         "
        hexmask.long.byte 0x00 4.--6. 1. " EMODE ,Endian Mode: The uSDHC supports all three endian modes in data transfer."
        textline "         "
        bitfld.long 0x00 6. " CDTL ,Card Detect Test Level: This is bit is enabled while the Card Detection Signal Selection is set to 1 and it indicates card insertion." "0,1"
        textline "         "
        bitfld.long 0x00 7. " CDSS ,Card Detect Signal Selection: This bit selects the source for the card detection." "0,1"
        textline "         "
        hexmask.long.byte 0x00 8.--10. 1. " DMASEL ,DMA Select: This field is valid while DMA (SDMA or ADMA) is enabled and selects the DMA operation."
        textline "         "
        bitfld.long 0x00 16. " SABGREQ ,Stop At Block Gap Request: This bit is used to stop executing a transaction at the next block gap for both DMA and non-DMA transfers." "0,1"
        textline "         "
        bitfld.long 0x00 17. " CREQ ,Continue Request: This bit is used to restart a transaction which was stopped using the Stop At Block Gap Request." "0,1"
        textline "         "
        bitfld.long 0x00 18. " RWCTL ,Read Wait Control: The read wait function is optional for SDIO cards." "0,1"
        textline "         "
        bitfld.long 0x00 19. " IABG ,Interrupt At Block Gap: This bit is valid only in 4-bit mode, of the SDIO card, and selects a sample point in the interrupt cycle." "0,1"
        textline "         "
        bitfld.long 0x00 20. " RD_DONE_NO_8CLK ,Read done no 8 clock: According to the SD/MMC spec, for read data transaction, 8 clocks are needed after the end bit of the last data block." "0,1"
        textline "         "
        bitfld.long 0x00 24. " WECINT ,Wakeup Event Enable On Card Interrupt: This bit enables a wakeup event, via a Card Interrupt, in the Interrupt Status register." "0,1"
        textline "         "
        bitfld.long 0x00 25. " WECINS ,Wakeup Event Enable On SD Card Insertion: This bit enables a wakeup event, via a Card Insertion, in the Interrupt Status register." "0,1"
        textline "         "
        bitfld.long 0x00 26. " WECRM ,Wakeup Event Enable On SD Card Removal: This bit enables a wakeup event, via a Card Removal, in the Interrupt Status register." "0,1"
        textline "         "
        hexmask.long.byte 0x00 27.--30. 1. " BURST_LEN_EN ,BURST length enable for INCR, INCR4/INCR8/INCR16, INCR4-WRAP/INCR8-WRAP/INCR16-WRAP This is used to enable/disable the burst length for the external AHB2AXI bridge."
        textline "         "
        bitfld.long 0x00 30. " NON_EXACT_BLK_RD ,Current block read is non-exact block read." "0,1"
width 9.
group.long 0x2c++0x3
    line.long 0x00 "SYS_CTRL,System Control"
        hexmask.long.byte 0x00 4.--8. 1. " DVS ,Divisor: This register is used to provide a more exact divisor to generate the desired SD clock frequency."
        textline "        "
        hexmask.long.byte 0x00 8.--16. 1. " SDCLKFS ,SDCLK Frequency Select: This register is used to select the frequency of the SDCLK pin."
        textline "        "
        hexmask.long.byte 0x00 16.--20. 1. " DTOCV ,Data Timeout Counter Value: This value determines the interval by which DAT line timeouts are detected."
        textline "        "
        bitfld.long 0x00 23. " IPP_RST_N ,This register's value will be output to CARD from pad directly for hardware reset of the card if the card supports this feature." "0,1"
        textline "        "
        bitfld.long 0x00 24. " RSTA ,Software Reset For ALL: This reset effects the entire Host Controller except for the card detection circuit." "0,1"
        textline "        "
        bitfld.long 0x00 25. " RSTC ,Software Reset For CMD Line: Only part of the command circuit is reset." "0,1"
        textline "        "
        bitfld.long 0x00 26. " RSTD ,Software Reset For DAT Line: Only part of the data circuit is reset." "0,1"
        textline "        "
        bitfld.long 0x00 27. " INITA ,Initialization Active: When this bit is set, 80 SD-Clocks are sent to the card." "0,1"
        textline "        "
        bitfld.long 0x00 28. " RSTT ,Reset Tuning: When set this bit to 1, it will reset tuning circuit." "0,1"
width 11.
group.long 0x30++0x3
    line.long 0x00 "INT_STATUS,Interrupt Status"
        bitfld.long 0x00 0. " CC ,Command Complete: This bit is set when you receive the end bit of the command response (except Auto CMD12)." "0,1"
        textline "          "
        bitfld.long 0x00 1. " TC ,Transfer Complete: This bit is set when a read or write transfer is completed." "0,1"
        textline "          "
        bitfld.long 0x00 2. " BGE ,Block Gap Event: If the Stop At Block Gap Request bit in the Protocol Control register is set, this bit is set when a read or write transaction is stopped at a block gap." "0,1"
        textline "          "
        bitfld.long 0x00 3. " DINT ,DMA Interrupt: Occurs only when the internal DMA finishes the data transfer successfully." "0,1"
        textline "          "
        bitfld.long 0x00 4. " BWR ,Buffer Write Ready: This status bit is set if the Buffer Write Enable bit, in the Present State register, changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 5. " BRR ,Buffer Read Ready: This status bit is set if the Buffer Read Enable bit, in the Present State register, changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 6. " CINS ,Card Insertion: This status bit is set if the Card Inserted bit in the Present State register changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 7. " CRM ,Card Removal: This status bit is set if the Card Inserted bit in the Present State register changes from 1 to 0." "0,1"
        textline "          "
        bitfld.long 0x00 8. " CINT ,Card Interrupt: This status bit is set when an interrupt signal is detected from the external card." "0,1"
        textline "          "
        bitfld.long 0x00 12. " RTE ,Re-Tuning Event: (only for SD3.0 SDR104 mode) This status is set if Re-Tuning Request in the Present State register changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 14. " TP ,Tuning Pass:(only for SD3.0 SDR104 mode) Current CMD19 transfer is done successfully." "0,1"
        textline "          "
        bitfld.long 0x00 16. " CTOE ,Command Timeout Error: Occurs only if no response is returned within 64 SDCLK cycles from the end bit of the command." "0,1"
        textline "          "
        bitfld.long 0x00 17. " CCE ,Command CRC Error: Command CRC Error is generated in two cases." "0,1"
        textline "          "
        bitfld.long 0x00 18. " CEBE ,Command End Bit Error: Occurs when detecting that the end bit of a command response is 0." "0,1"
        textline "          "
        bitfld.long 0x00 19. " CIE ,Command Index Error: Occurs if a Command Index error occurs in the command response." "0,1"
        textline "          "
        bitfld.long 0x00 20. " DTOE ,Data Timeout Error: Occurs when detecting one of following time-out conditions." "0,1"
        textline "          "
        bitfld.long 0x00 21. " DCE ,Data CRC Error: Occurs when detecting a CRC error when transferring read data, which uses the DAT line, or when detecting the Write CRC status having a value other than 010." "0,1"
        textline "          "
        bitfld.long 0x00 22. " DEBE ,Data End Bit Error: Occurs either when detecting 0 at the end bit position of read data, which uses the DAT line, or at the end bit position of the CRC." "0,1"
        textline "          "
        bitfld.long 0x00 24. " AC12E ,Auto CMD12 Error: Occurs when detecting that one of the bits in the Auto CMD12 Error Status register has changed from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 26. " TNE ,Tuning Error: (only for SD3.0 SDR104 mode) This bit is set when an unrecoverable error is detected in a tuning circuit." "0,1"
        textline "          "
        bitfld.long 0x00 28. " DMAE ,DMA Error: Occurs when an Internal DMA transfer has failed." "0,1"
width 14.
group.long 0x34++0x3
    line.long 0x00 "INT_STATUS_EN,Interrupt Status Enable"
        bitfld.long 0x00 0. " CCSEN ,Command Complete Status Enable: 1 Enabled 0 Masked" "0,1"
        textline "             "
        bitfld.long 0x00 1. " TCSEN ,Transfer Complete Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 2. " BGESEN ,Block Gap Event Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 3. " DINTSEN ,DMA Interrupt Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 4. " BWRSEN ,Buffer Write Ready Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 5. " BRRSEN ,Buffer Read Ready Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 6. " CINSSEN ,Card Insertion Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 7. " CRMSEN ,Card Removal Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 8. " CINTSEN ,Card Interrupt Status Enable: If this bit is set to 0, the uSDHC will clear the interrupt request to the System." "0,1"
        textline "             "
        bitfld.long 0x00 12. " RTESEN ,Re-Tuning Event Status Enable" "0,1"
        textline "             "
        bitfld.long 0x00 14. " TPSEN ,Tuning Pass Status Enable" "0,1"
        textline "             "
        bitfld.long 0x00 16. " CTOESEN ,Command Timeout Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 17. " CCESEN ,Command CRC Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 18. " CEBESEN ,Command End Bit Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 19. " CIESEN ,Command Index Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 20. " DTOESEN ,Data Timeout Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 21. " DCESEN ,Data CRC Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 22. " DEBESEN ,Data End Bit Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 24. " AC12ESEN ,Auto CMD12 Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 26. " TNESEN ,Tuning Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 28. " DMAESEN ,DMA Error Status Enable:" "0,1"
width 14.
group.long 0x38++0x3
    line.long 0x00 "INT_SIGNAL_EN,Interrupt Signal Enable"
        bitfld.long 0x00 0. " CCIEN ,Command Complete Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 1. " TCIEN ,Transfer Complete Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 2. " BGEIEN ,Block Gap Event Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 3. " DINTIEN ,DMA Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 4. " BWRIEN ,Buffer Write Ready Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 5. " BRRIEN ,Buffer Read Ready Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 6. " CINSIEN ,Card Insertion Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 7. " CRMIEN ,Card Removal Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 8. " CINTIEN ,Card Interrupt Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 12. " RTEIEN ,Re-Tuning Event Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 14. " TPIEN ,Tuning Pass Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 16. " CTOEIEN ,Command Timeout Error Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 17. " CCEIEN ,Command CRC Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 18. " CEBEIEN ,Command End Bit Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 19. " CIEIEN ,Command Index Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 20. " DTOEIEN ,Data Timeout Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 21. " DCEIEN ,Data CRC Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 22. " DEBEIEN ,Data End Bit Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 24. " AC12EIEN ,Auto CMD12 Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 26. " TNEIEN ,Tuning Error Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 28. " DMAEIEN ,DMA Error Interrupt Enable:" "0,1"
width 21.
rgroup.long 0x3c++0x3
    line.long 0x00 "AUTOCMD12_ERR_STATUS,Auto CMD12 Error Status"
        bitfld.long 0x00 0. " AC12NE ,Auto CMD12 Not Executed: If memory multiple block data transfer is not started, due to a command error, this bit is not set because it is not necessary to issue an Auto CMD12." "0,1"
        textline "                    "
        bitfld.long 0x00 1. " AC12TOE ,Auto CMD12 Timeout Error: Occurs if no response is returned within 64 SDCLK cycles from the end bit of the command." "0,1"
        textline "                    "
        bitfld.long 0x00 2. " AC12EBE ,Auto CMD12 End Bit Error: Occurs when detecting that the end bit of command response is 0 which should be 1." "0,1"
        textline "                    "
        bitfld.long 0x00 3. " AC12CE ,Auto CMD12 CRC Error: Occurs when detecting a CRC error in the command response." "0,1"
        textline "                    "
        bitfld.long 0x00 4. " AC12IE ,Auto CMD12 Index Error: Occurs if the Command Index error occurs in response to a command." "0,1"
        textline "                    "
        bitfld.long 0x00 7. " CNIBAC12E ,Command Not Issued By Auto CMD12 Error: Setting this bit to 1 means CMD_wo_DAT is not executed due to an Auto CMD12 Error (D04-D01) in this register." "0,1"
        textline "                    "
        bitfld.long 0x00 22. " EXECUTE_TUNING ,Execute Tuning: When std_tuning_en bit is set, this bit is used to start tuning procedure." "0,1"
        textline "                    "
        bitfld.long 0x00 23. " SMP_CLK_SEL ,Sample Clock Select: When std_tuning_en bit is set, this bit is used to select sampling clock to receive CMD and DAT." "0,1"
width 14.
rgroup.long 0x40++0x3
    line.long 0x00 "HOST_CTRL_CAP,Host Controller Capabilities"
        bitfld.long 0x00 0. " SDR50_SUPPORT ,SDR50 support: This bit indicates support of SDR50 mode." "0,1"
        textline "             "
        bitfld.long 0x00 1. " SDR104_SUPPORT ,SDR104 support: This bit indicates support of SDR104 mode." "0,1"
        textline "             "
        bitfld.long 0x00 2. " DDR50_SUPPORT ,DDR50 support: This bit indicates support of DDR50 mode." "0,1"
        textline "             "
        hexmask.long.byte 0x00 8.--12. 1. " TIME_COUNT_RETUNING ,Time counter for retuning: This bit indicates an initial value of the Retuning Timer for Re-Tuning Mode1 and 3.Setting to 0 disables Retuning Timer."
        textline "             "
        bitfld.long 0x00 13. " USE_TUNING_SDR50 ,Use Tuning for SDR50: This bit is set to 1." "0,1"
        textline "             "
        hexmask.long.byte 0x00 14.--16. 1. " RETUNING_MODE ,Retuning Mode: This bit selects retuning method."
        textline "             "
        hexmask.long.byte 0x00 16.--19. 1. " MBL ,Max Block Length: This value indicates the maximum block size that the Host Driver can read and write to the buffer in the uSDHC."
        textline "             "
        bitfld.long 0x00 20. " ADMAS ,ADMA Support: This bit indicates whether the uSDHC supports the ADMA feature." "0,1"
        textline "             "
        bitfld.long 0x00 21. " HSS ,High Speed Support: This bit indicates whether the uSDHC supports High Speed mode and the Host System can supply a SD Clock frequency from 25 MHz to 50 MHz." "0,1"
        textline "             "
        bitfld.long 0x00 22. " DMAS ,DMA Support: This bit indicates whether the uSDHC is capable of using the internal DMA to transfer data between system memory and the data buffer directly." "0,1"
        textline "             "
        bitfld.long 0x00 23. " SRS ,Suspend / Resume Support: This bit indicates whether the uSDHC supports Suspend / Resume functionality." "0,1"
        textline "             "
        bitfld.long 0x00 24. " VS33 ,Voltage Support 3.3V: This bit shall depend on the Host System ability." "0,1"
        textline "             "
        bitfld.long 0x00 25. " VS30 ,Voltage Support 3.0V: This bit shall depend on the Host System ability." "0,1"
        textline "             "
        bitfld.long 0x00 26. " VS18 ,Voltage Support 1.8V: This bit shall depend on the Host System ability." "0,1"
width 9.
group.long 0x44++0x3
    line.long 0x00 "WTMK_LVL,Watermark Level"
        hexmask.long.byte 0x00 0.--8. 1. " RD_WML ,Read Watermark Level: The number of words used as the watermark level (FIFO threshold) in a DMA read operation."
        textline "        "
        hexmask.long.byte 0x00 8.--13. 1. " RD_BRST_LEN ,Read Burst Length: Due to system restriction, the actual burst length may not exceed 16."
        textline "        "
        hexmask.long.byte 0x00 16.--24. 1. " WR_WML ,Write Watermark Level: The number of words used as the watermark level (FIFO threshold) in a DMA write operation."
        textline "        "
        hexmask.long.byte 0x00 24.--29. 1. " WR_BRST_LEN ,Write Burst Length: Due to system restriction, the actual burst length may not exceed 16."
width 9.
group.long 0x48++0x3
    line.long 0x00 "MIX_CTRL,Mixer Control"
        bitfld.long 0x00 0. " DMAEN ,DMA Enable: This bit enables DMA functionality." "0,1"
        textline "        "
        bitfld.long 0x00 1. " BCEN ,Block Count Enable: This bit is used to enable the Block Count register, which is only relevant for multiple block transfers." "0,1"
        textline "        "
        bitfld.long 0x00 2. " AC12EN ,Auto CMD12 Enable: Multiple block transfers for memory require a CMD12 to stop the transaction." "0,1"
        textline "        "
        bitfld.long 0x00 3. " DDR_EN ,Dual Data Rate mode selection" "0,1"
        textline "        "
        bitfld.long 0x00 4. " DTDSEL ,Data Transfer Direction Select: This bit defines the direction of DAT line data transfers." "0,1"
        textline "        "
        bitfld.long 0x00 5. " MSBSEL ,Multi / Single Block Select: This bit enables multiple block DAT line data transfers." "0,1"
        textline "        "
        bitfld.long 0x00 6. " NIBBLE_POS ,In DDR 4-bit mode nibble position indictation." "0,1"
        textline "        "
        bitfld.long 0x00 7. " AC23EN ,Auto CMD23 Enable When this bit is set to 1, the Host Controller issues a CMD23 automatically before issuing a command specified in the Command Register." "0,1"
        textline "        "
        bitfld.long 0x00 22. " EXE_TUNE ,Execute Tuning: (Only used for SD3.0, SDR104 mode) When std_tuning_en is 0, this bit is set to 1 to indicate the Host Driver is starting tuning procedure." "0,1"
        textline "        "
        bitfld.long 0x00 23. " SMP_CLK_SEL ,When std_tuning_en is 0, this bit is used to select Tuned clock or Fixed clock to sample data/cmd (Only used for SD3.0, SDR104 mode)" "0,1"
        textline "        "
        bitfld.long 0x00 24. " AUTO_TUNE_EN ,Auto tuning enable (Only used for SD3.0, SDR104 mode)" "0,1"
        textline "        "
        bitfld.long 0x00 25. " FBCLK_SEL ,Feedback clock source selection (Only used for SD3.0, SDR104 mode)" "0,1"
width 12.
wgroup.long 0x50++0x3
    line.long 0x00 "FORCE_EVENT,Force Event"
        bitfld.long 0x00 0. " FEVTAC12NE ,Force Event Auto Command 12 Not Executed: Forces the AC12NE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 1. " FEVTAC12TOE ,Force Event Auto Command 12 Time Out Error: Forces the AC12TOE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 2. " FEVTAC12CE ,Force Event Auto Command 12 CRC Error: Forces the AC12CE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 3. " FEVTAC12EBE ,Force Event Auto Command 12 End Bit Error: Forces the AC12EBE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 4. " FEVTAC12IE ,Force Event Auto Command 12 Index Error: Forces the AC12IE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 7. " FEVTCNIBAC12E ,Force Event Command Not Executed By Auto Command 12 Error: Forces the CNIBAC12E bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 16. " FEVTCTOE ,Force Event Command Time Out Error: Forces the CTOE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 17. " FEVTCCE ,Force Event Command CRC Error: Forces the CCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 18. " FEVTCEBE ,Force Event Command End Bit Error: Forces the CEBE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 19. " FEVTCIE ,Force Event Command Index Error: Forces the CCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 20. " FEVTDTOE ,Force Event Data Time Out Error: Force the DTOE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 21. " FEVTDCE ,Force Event Data CRC Error: Forces the DCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 22. " FEVTDEBE ,Force Event Data End Bit Error: Forces the DEBE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 24. " FEVTAC12E ,Force Event Auto Command 12 Error: Forces the AC12E bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 26. " FEVTTNE ,Force Tuning Error: Forces the TNE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 28. " FEVTDMAE ,Force Event DMA Error: Forces the DMAE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 31. " FEVTCINT ,Force Event Card Interrupt: Writing 1 to this bit generates a short low-level pulse on the internal DAT[1] line, as if a self clearing interrupt was received from the external card." "0,1"
width 16.
rgroup.long 0x54++0x3
    line.long 0x00 "ADMA_ERR_STATUS,ADMA Error Status Register"
        hexmask.long.byte 0x00 0.--2. 1. " ADMAES ,ADMA Error State (when ADMA Error is occurred.): This field indicates the state of the ADMA when an error has occurred during an ADMA data transfer."
        textline "               "
        bitfld.long 0x00 2. " ADMALME ,ADMA Length Mismatch Error: This error occurs in the following 2 cases: While the Block Count Enable is being set, the total data length specified by the Descriptor table is different from that specified by the Block Count and Block Length Total data length can not be divided by the block length" "0,1"
        textline "               "
        bitfld.long 0x00 3. " ADMADCE ,ADMA Descritor Error: This error occurs when invalid descriptor fetched by ADMA:" "0,1"
width 14.
group.long 0x58++0x3
    line.long 0x00 "ADMA_SYS_ADDR,ADMA System Address"
        hexmask.long.long 0x00 2.--32. 1. " ADS_ADDR ,ADMA System Address: This register holds the word address of the executing command in the Descriptor table."
width 9.
group.long 0x60++0x3
    line.long 0x00 "DLL_CTRL,DLL (Delay Line) Control"
        bitfld.long 0x00 0. " DLL_CTRL_ENABLE ,Set this bit to 1 to enable the DLL and delay chain; otherwise; set to 0 to bypasses DLL." "0,1"
        textline "        "
        bitfld.long 0x00 1. " DLL_CTRL_RESET ,Setting this bit to 1 force a reset on DLL." "0,1"
        textline "        "
        bitfld.long 0x00 2. " DLL_CTRL_SLV_FORCE_UPD ,Setting this bit to 1, forces the slave delay line to update to the DLL calibrated value immediately." "0,1"
        textline "        "
        hexmask.long.byte 0x00 3.--7. 1. " DLL_CTRL_SLV_DLY_TARGET0 ,The delay target for the uSDHC loopback read clock can be programmed in 1/16th increments of an ref_clock half-period."
        textline "        "
        bitfld.long 0x00 7. " DLL_CTRL_GATE_UPDATE ,Set this bit to 1 to prevent the DLL from updating (since when clock_in exists, glitches may appear during DLL updates)." "0,1"
        textline "        "
        bitfld.long 0x00 8. " DLL_CTRL_SLV_OVERRIDE ,Set this bit to 1 to Enable manual override for slave delay chain using SLV_OVERRIDE_VAL; to set 0 to disable manual override." "0,1"
        textline "        "
        hexmask.long.byte 0x00 9.--16. 1. " DLL_CTRL_SLV_OVERRIDE_VAL ,When SLV_OVERRIDE=1 This field is used to select 1 of 128 physical taps manually."
        textline "        "
        hexmask.long.byte 0x00 16.--19. 1. " DLL_CTRL_SLV_DLY_TARGET1 ,Refer to DLL_CTRL_SLV_DLY_TARGET0 below."
        textline "        "
        hexmask.long.byte 0x00 20.--28. 1. " DLL_CTRL_SLV_UPDATE_INT ,Slave delay line update interval."
        textline "        "
        hexmask.long.byte 0x00 28.--32. 1. " DLL_CTRL_REF_UPDATE_INT ,DLL control loop update interval."
width 11.
rgroup.long 0x64++0x3
    line.long 0x00 "DLL_STATUS,DLL Status"
        bitfld.long 0x00 0. " DLL_STS_SLV_LOCK ,Slave delay-line lock status." "0,1"
        textline "          "
        bitfld.long 0x00 1. " DLL_STS_REF_LOCK ,Reference DLL lock status." "0,1"
        textline "          "
        hexmask.long.byte 0x00 2.--9. 1. " DLL_STS_SLV_SEL ,Slave delay line select status."
        textline "          "
        hexmask.long.byte 0x00 9.--16. 1. " DLL_STS_REF_SEL ,Reference delay line select taps."
width 21.
group.long 0x68++0x3
    line.long 0x00 "CLK_TUNE_CTRL_STATUS,CLK Tuning Control and Status"
        hexmask.long.byte 0x00 0.--4. 1. " DLY_CELL_SET_POST ,Set the number of delay cells on the feedback clock between CLK_OUT and CLK_POST."
        textline "                    "
        hexmask.long.byte 0x00 4.--8. 1. " DLY_CELL_SET_OUT ,Set the number of delay cells on the feedback clock between CLK_PRE and CLK_OUT."
        textline "                    "
        hexmask.long.byte 0x00 8.--15. 1. " DLY_CELL_SET_PRE ,Set the number of delay cells on the feedback clock between the feedback clock and CLK_PRE."
        textline "                    "
        bitfld.long 0x00 15. " NXT_ERR ,NXT error which means the number of delay cells added on the feedback clock is too large." "0,1"
        textline "                    "
        hexmask.long.byte 0x00 16.--20. 1. " TAP_SEL_POST ,Reflect the number of delay cells added on the feedback clock between CLK_OUT and CLK_POST."
        textline "                    "
        hexmask.long.byte 0x00 20.--24. 1. " TAP_SEL_OUT ,Reflect the number of delay cells added on the feedback clock between CLK_PRE and CLK_OUT."
        textline "                    "
        hexmask.long.byte 0x00 24.--31. 1. " TAP_SEL_PRE ,Reflects the number of delay cells added on the feedback clock between the feedback clock and CLK_PRE."
        textline "                    "
        bitfld.long 0x00 31. " PRE_ERR ,PRE error which means the number of delay cells added on the feedback clock is too small." "0,1"
width 10.
group.long 0xc0++0x3
    line.long 0x00 "VEND_SPEC,Vendor Specific Register"
        bitfld.long 0x00 0. " EXT_DMA_EN ,External DMA Request Enable Enable the request to external DMA." "0,1"
        textline "         "
        bitfld.long 0x00 1. " VSELECT ,Voltage Selection Change the value of output signal VSELECT, to control the voltage on pads for external card." "0,1"
        textline "         "
        bitfld.long 0x00 2. " CONFLICT_CHK_EN ,It's not implemented in uSDHC IP." "0,1"
        textline "         "
        bitfld.long 0x00 3. " AC12_WR_CHKBUSY_EN ,Check busy enable after auto CMD12 for write data packet" "0,1"
        textline "         "
        bitfld.long 0x00 4. " DAT3_CD_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 5. " CD_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 6. " WP_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 7. " CLKONJ_IN_ABORT ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 8. " FRC_SDCLK_ON ,Force CLK output active:" "0,1"
        textline "         "
        bitfld.long 0x00 11. " IPG_CLK_SOFT_EN ,IPG_CLK software enable" "0,1"
        textline "         "
        bitfld.long 0x00 12. " HCLK_SOFT_EN ,Please note, hardware auto-enables the AHB clock when the internal DMA is enabled even if HCLK_SOFT_EN is 0." "0,1"
        textline "         "
        bitfld.long 0x00 13. " IPG_PERCLK_SOFT_EN ,ipg_perclk software enable" "0,1"
        textline "         "
        bitfld.long 0x00 14. " CARD_CLK_SOFT_EN ,card clock software enable" "0,1"
        textline "         "
        bitfld.long 0x00 15. " CRC_CHK_DIS ,CRC check disable" "0,1"
        textline "         "
        hexmask.long.byte 0x00 16.--24. 1. " INT_ST_VAL ,Internal State Value Internal state value, reflecting the corresponding state value selected by Debug Select field."
width 9.
group.long 0xc4++0x3
    line.long 0x00 "MMC_BOOT,MMC Boot Register"
        hexmask.long.byte 0x00 0.--4. 1. " DTOCV_ACK ,Boot ACK time out counter value."
        textline "        "
        bitfld.long 0x00 4. " BOOT_ACK ,Boot ack mode select." "0,1"
        textline "        "
        bitfld.long 0x00 5. " BOOT_MODE ,Boot mode select." "0,1"
        textline "        "
        bitfld.long 0x00 6. " BOOT_EN ,Boot mode enable." "0,1"
        textline "        "
        bitfld.long 0x00 7. " AUTO_SABG_EN ,During boot, enable auto stop at block gap function." "0,1"
        textline "        "
        bitfld.long 0x00 8. " DISABLE_TIME_OUT ,Please note, when this bit is set, there is no timeout check no matter whether boot_en is set or not." "0,1"
        textline "        "
        hexmask.long.word 0x00 16.--32. 1. " BOOT_BLK_CNT ,The value defines the Stop At Block Gap value of automatic mode."
width 11.
group.long 0xc8++0x3
    line.long 0x00 "VEND_SPEC2,Vendor Specific 2 Register"
        bitfld.long 0x00 0. " SDR104_TIMING_DIS ,Timeout counter test." "0,1"
        textline "          "
        bitfld.long 0x00 1. " SDR104_OE_DIS ,CMD_OE/DAT_OE logic generation test." "0,1"
        textline "          "
        bitfld.long 0x00 2. " SDR104_NSD_DIS ,Interrupt window after abort command is sent." "0,1"
        textline "          "
        bitfld.long 0x00 3. " CARD_INT_D3_TEST ,Card interrupt detection test." "0,1"
        textline "          "
        bitfld.long 0x00 4. " TUNING_8BIT_EN ,Enable the auto tuning circuit to check the DAT[7:0]." "0,1"
        textline "          "
        bitfld.long 0x00 5. " TUNING_1BIT_EN ,Enable the auto tuning circuit to check the DAT0 only." "0,1"
        textline "          "
        bitfld.long 0x00 6. " TUNING_CMD_EN ,Enable the auto tuning circuit to check the CMD line." "0,1"
        textline "          "
        bitfld.long 0x00 7. " CARD_INT_AUTO_CLR_DIS ,Disable the feature to clear the Card interrupt status bit when Card Interrupt status enable bit is cleared." "0,1"
width 12.
group.long 0xcc++0x3
    line.long 0x00 "TUNING_CTRL,Tuning Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " TUNING_START_TAP ,The start dealy cell point when send first CMD19 in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 8.--16. 1. " TUNING_COUNTER ,The MAX repeat CMD19 times in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 16.--19. 1. " TUNING_STEP ,The increasing delay cell step in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 20.--23. 1. " TUNING_WINDOW ,Select data window value for auto tuning"
        textline "           "
        bitfld.long 0x00 24. " STD_TUNING_EN ,Standard tuning circuit and procedure enable: This bit is used to enable standard tuning circuit and procedure." "0,1"


    tree.end
    tree "USDHC4"
        base ad:0x0219c000

width 8.
group.long 0x0++0x3
    line.long 0x00 "DS_ADDR,DMA System Address"
        hexmask.long.long 0x00 2.--32. 1. " DS_ADDR ,DMA System Address: This register contains the 32-bit system memory address for a DMA transfer."
width 8.
group.long 0x4++0x3
    line.long 0x00 "BLK_ATT,Block Attributes"
        hexmask.long.word 0x00 0.--13. 1. " BLKSIZE ,Transfer Block Size: This register specifies the block size for block data transfers."
        textline "       "
        hexmask.long.word 0x00 16.--32. 1. " BLKCNT ,Blocks Count For Current Transfer: This register is enabled when the Block Count Enable bit in the Transfer Mode register is set to 1 and is valid only for multiple block transfers."
width 8.
group.long 0x8++0x3
    line.long 0x00 "CMD_ARG,Command Argument"
        hexmask.long.long 0x00 0.--32. 1. " CMDARG ,Command Argument: The SD/MMC Command Argument is specified as bits 39-8 of the Command Format in the SD or MMC Specification.This register is write protected when the Command Inhibit (CMD) bit in the Present State register is set."
width 12.
group.long 0xc++0x3
    line.long 0x00 "CMD_XFR_TYP,Command Transfer Type"
        hexmask.long.byte 0x00 16.--18. 1. " RSPTYP ,Response Type Select:"
        textline "           "
        bitfld.long 0x00 19. " CCCEN ,Command CRC Check Enable: If this bit is set to 1, the uSDHC shall check the CRC field in the response." "0,1"
        textline "           "
        bitfld.long 0x00 20. " CICEN ,Command Index Check Enable: If this bit is set to 1, the uSDHC will check the Index field in the response to see if it has the same value as the command index." "0,1"
        textline "           "
        bitfld.long 0x00 21. " DPSEL ,Data Present Select: This bit is set to 1 to indicate that data is present and shall be transferred using the DAT line." "0,1"
        textline "           "
        hexmask.long.byte 0x00 22.--24. 1. " CMDTYP ,Command Type: There are three types of special commands: Suspend, Resume and Abort."
        textline "           "
        hexmask.long.byte 0x00 24.--30. 1. " CMDINX ,Command Index: These bits shall be set to the command number that is specified in bits 45-40 of the Command-Format in the SD Memory Card Physical Layer Specification and SDIO Card Specification."
width 9.
rgroup.long 0x10++0x3
    line.long 0x00 "CMD_RSP0,Command Response0"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP0 ,Command Response 0: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x14++0x3
    line.long 0x00 "CMD_RSP1,Command Response1"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP1 ,Command Response 1: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x18++0x3
    line.long 0x00 "CMD_RSP2,Command Response2"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP2 ,Command Response 2: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 9.
rgroup.long 0x1c++0x3
    line.long 0x00 "CMD_RSP3,Command Response3"
        hexmask.long.long 0x00 0.--32. 1. " CMDRSP3 ,Command Response 3: Refer to for the mapping of command responses from the SD Bus to this register for each response type."
width 19.
group.long 0x20++0x3
    line.long 0x00 "DATA_BUFF_ACC_PORT,Data Buffer Access Port"
        hexmask.long.long 0x00 0.--32. 1. " DATCONT ,Data Content: The Buffer Data Port register is for 32-bit data access by the ARM platform or the external DMA."
width 11.
rgroup.long 0x24++0x3
    line.long 0x00 "PRES_STATE,Present State"
        bitfld.long 0x00 0. " CIHB ,Command Inhibit (CMD): If this status bit is 0, it indicates that the CMD line is not in use and the uSDHC can issue a SD/MMC Command using the CMD line." "0,1"
        textline "          "
        bitfld.long 0x00 1. " CDIHB ,Command Inhibit (DAT): This status bit is generated if either the DAT Line Active or the Read Transfer Active is set to 1." "0,1"
        textline "          "
        bitfld.long 0x00 2. " DLA ,Data Line Active This status bit indicates whether one of the DAT lines on the SD Bus is in use." "0,1"
        textline "          "
        bitfld.long 0x00 3. " SDSTB ,SD Clock Stable This status bit indicates that the internal card clock is stable." "0,1"
        textline "          "
        bitfld.long 0x00 4. " IPGOFF ,ipg_clk Gated Off Internally: This status bit indicates that the ipg_clk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 5. " HCKOFF ,hclk Gated Off Internally: This status bit indicates that the hclk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 6. " PEROFF ,ipg_perclk Gated Off Internally: This status bit indicates that the ipg_perclk is internally gated off." "0,1"
        textline "          "
        bitfld.long 0x00 7. " SDOFF ,SD Clock Gated Off Internally: This status bit indicates that the SD Clock is internally gated off, because of buffer over/under-run or read pause without read wait assertion, or the driver set FRC_SDCLK_ON bit is 0 to stop the SD clock in idle status." "0,1"
        textline "          "
        bitfld.long 0x00 8. " WTA ,Write Transfer Active: This status bit indicates a write transfer is active." "0,1"
        textline "          "
        bitfld.long 0x00 9. " RTA ,Read Transfer Active: This status bit is used for detecting completion of a read transfer." "0,1"
        textline "          "
        bitfld.long 0x00 10. " BWEN ,Buffer Write Enable: This status bit is used for non-DMA write transfers." "0,1"
        textline "          "
        bitfld.long 0x00 11. " BREN ,Buffer Read Enable: This status bit is used for non-DMA read transfers." "0,1"
        textline "          "
        bitfld.long 0x00 12. " RTR ,Re-Tuning Request: (only for SD3.0 SDR104 mode) Host Controller may request Host Driver to execute re-tuning sequence by setting this bit when the data window is shifted by temperature drift and a tuned sampling point does not have a good margin to receive correct data." "0,1"
        textline "          "
        bitfld.long 0x00 15. " TSCD ,Tape Select Change Done : This bit indicates the dealy setting is effective after write CLK_TUNE_CTRL_STATUS register." "0,1"
        textline "          "
        bitfld.long 0x00 16. " CINST ,Card Inserted: This bit indicates whether a card has been inserted." "0,1"
        textline "          "
        bitfld.long 0x00 18. " CDPL ,Card Detect Pin Level: This bit reflects the inverse value of the CD# pin for the card socket." "0,1"
        textline "          "
        bitfld.long 0x00 19. " WPSPL ,Write Protect Switch Pin Level: The Write Protect Switch is supported for memory and combo cards.This bit reflects the inverted value of the WP pin of the card socket." "0,1"
        textline "          "
        bitfld.long 0x00 23. " CLSL ,CMD Line Signal Level: This status is used to check the CMD line level to recover from errors, and for debugging." "0,1"
        textline "          "
        hexmask.long.byte 0x00 24.--32. 1. " DLSL ,DAT[7:0] Line Signal Level: This status is used to check the DAT line level to recover from errors, and for debugging.This is especially useful in detecting the busy signal level from DAT[0]."
width 10.
group.long 0x28++0x3
    line.long 0x00 "PROT_CTRL,Protocol Control"
        bitfld.long 0x00 0. " LCTL ,LED Control: This bit, fully controlled by the Host Driver, is used to caution the user not to remove the card while the card is being accessed." "0,1"
        textline "         "
        hexmask.long.byte 0x00 1.--3. 1. " DTW ,Data Transfer Width: This bit selects the data width of the SD bus for a data transfer."
        textline "         "
        bitfld.long 0x00 3. " D3CD ,DAT3 as Card Detection Pin: If this bit is set, DAT3 should be pulled down to act as a card detection pin." "0,1"
        textline "         "
        hexmask.long.byte 0x00 4.--6. 1. " EMODE ,Endian Mode: The uSDHC supports all three endian modes in data transfer."
        textline "         "
        bitfld.long 0x00 6. " CDTL ,Card Detect Test Level: This is bit is enabled while the Card Detection Signal Selection is set to 1 and it indicates card insertion." "0,1"
        textline "         "
        bitfld.long 0x00 7. " CDSS ,Card Detect Signal Selection: This bit selects the source for the card detection." "0,1"
        textline "         "
        hexmask.long.byte 0x00 8.--10. 1. " DMASEL ,DMA Select: This field is valid while DMA (SDMA or ADMA) is enabled and selects the DMA operation."
        textline "         "
        bitfld.long 0x00 16. " SABGREQ ,Stop At Block Gap Request: This bit is used to stop executing a transaction at the next block gap for both DMA and non-DMA transfers." "0,1"
        textline "         "
        bitfld.long 0x00 17. " CREQ ,Continue Request: This bit is used to restart a transaction which was stopped using the Stop At Block Gap Request." "0,1"
        textline "         "
        bitfld.long 0x00 18. " RWCTL ,Read Wait Control: The read wait function is optional for SDIO cards." "0,1"
        textline "         "
        bitfld.long 0x00 19. " IABG ,Interrupt At Block Gap: This bit is valid only in 4-bit mode, of the SDIO card, and selects a sample point in the interrupt cycle." "0,1"
        textline "         "
        bitfld.long 0x00 20. " RD_DONE_NO_8CLK ,Read done no 8 clock: According to the SD/MMC spec, for read data transaction, 8 clocks are needed after the end bit of the last data block." "0,1"
        textline "         "
        bitfld.long 0x00 24. " WECINT ,Wakeup Event Enable On Card Interrupt: This bit enables a wakeup event, via a Card Interrupt, in the Interrupt Status register." "0,1"
        textline "         "
        bitfld.long 0x00 25. " WECINS ,Wakeup Event Enable On SD Card Insertion: This bit enables a wakeup event, via a Card Insertion, in the Interrupt Status register." "0,1"
        textline "         "
        bitfld.long 0x00 26. " WECRM ,Wakeup Event Enable On SD Card Removal: This bit enables a wakeup event, via a Card Removal, in the Interrupt Status register." "0,1"
        textline "         "
        hexmask.long.byte 0x00 27.--30. 1. " BURST_LEN_EN ,BURST length enable for INCR, INCR4/INCR8/INCR16, INCR4-WRAP/INCR8-WRAP/INCR16-WRAP This is used to enable/disable the burst length for the external AHB2AXI bridge."
        textline "         "
        bitfld.long 0x00 30. " NON_EXACT_BLK_RD ,Current block read is non-exact block read." "0,1"
width 9.
group.long 0x2c++0x3
    line.long 0x00 "SYS_CTRL,System Control"
        hexmask.long.byte 0x00 4.--8. 1. " DVS ,Divisor: This register is used to provide a more exact divisor to generate the desired SD clock frequency."
        textline "        "
        hexmask.long.byte 0x00 8.--16. 1. " SDCLKFS ,SDCLK Frequency Select: This register is used to select the frequency of the SDCLK pin."
        textline "        "
        hexmask.long.byte 0x00 16.--20. 1. " DTOCV ,Data Timeout Counter Value: This value determines the interval by which DAT line timeouts are detected."
        textline "        "
        bitfld.long 0x00 23. " IPP_RST_N ,This register's value will be output to CARD from pad directly for hardware reset of the card if the card supports this feature." "0,1"
        textline "        "
        bitfld.long 0x00 24. " RSTA ,Software Reset For ALL: This reset effects the entire Host Controller except for the card detection circuit." "0,1"
        textline "        "
        bitfld.long 0x00 25. " RSTC ,Software Reset For CMD Line: Only part of the command circuit is reset." "0,1"
        textline "        "
        bitfld.long 0x00 26. " RSTD ,Software Reset For DAT Line: Only part of the data circuit is reset." "0,1"
        textline "        "
        bitfld.long 0x00 27. " INITA ,Initialization Active: When this bit is set, 80 SD-Clocks are sent to the card." "0,1"
        textline "        "
        bitfld.long 0x00 28. " RSTT ,Reset Tuning: When set this bit to 1, it will reset tuning circuit." "0,1"
width 11.
group.long 0x30++0x3
    line.long 0x00 "INT_STATUS,Interrupt Status"
        bitfld.long 0x00 0. " CC ,Command Complete: This bit is set when you receive the end bit of the command response (except Auto CMD12)." "0,1"
        textline "          "
        bitfld.long 0x00 1. " TC ,Transfer Complete: This bit is set when a read or write transfer is completed." "0,1"
        textline "          "
        bitfld.long 0x00 2. " BGE ,Block Gap Event: If the Stop At Block Gap Request bit in the Protocol Control register is set, this bit is set when a read or write transaction is stopped at a block gap." "0,1"
        textline "          "
        bitfld.long 0x00 3. " DINT ,DMA Interrupt: Occurs only when the internal DMA finishes the data transfer successfully." "0,1"
        textline "          "
        bitfld.long 0x00 4. " BWR ,Buffer Write Ready: This status bit is set if the Buffer Write Enable bit, in the Present State register, changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 5. " BRR ,Buffer Read Ready: This status bit is set if the Buffer Read Enable bit, in the Present State register, changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 6. " CINS ,Card Insertion: This status bit is set if the Card Inserted bit in the Present State register changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 7. " CRM ,Card Removal: This status bit is set if the Card Inserted bit in the Present State register changes from 1 to 0." "0,1"
        textline "          "
        bitfld.long 0x00 8. " CINT ,Card Interrupt: This status bit is set when an interrupt signal is detected from the external card." "0,1"
        textline "          "
        bitfld.long 0x00 12. " RTE ,Re-Tuning Event: (only for SD3.0 SDR104 mode) This status is set if Re-Tuning Request in the Present State register changes from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 14. " TP ,Tuning Pass:(only for SD3.0 SDR104 mode) Current CMD19 transfer is done successfully." "0,1"
        textline "          "
        bitfld.long 0x00 16. " CTOE ,Command Timeout Error: Occurs only if no response is returned within 64 SDCLK cycles from the end bit of the command." "0,1"
        textline "          "
        bitfld.long 0x00 17. " CCE ,Command CRC Error: Command CRC Error is generated in two cases." "0,1"
        textline "          "
        bitfld.long 0x00 18. " CEBE ,Command End Bit Error: Occurs when detecting that the end bit of a command response is 0." "0,1"
        textline "          "
        bitfld.long 0x00 19. " CIE ,Command Index Error: Occurs if a Command Index error occurs in the command response." "0,1"
        textline "          "
        bitfld.long 0x00 20. " DTOE ,Data Timeout Error: Occurs when detecting one of following time-out conditions." "0,1"
        textline "          "
        bitfld.long 0x00 21. " DCE ,Data CRC Error: Occurs when detecting a CRC error when transferring read data, which uses the DAT line, or when detecting the Write CRC status having a value other than 010." "0,1"
        textline "          "
        bitfld.long 0x00 22. " DEBE ,Data End Bit Error: Occurs either when detecting 0 at the end bit position of read data, which uses the DAT line, or at the end bit position of the CRC." "0,1"
        textline "          "
        bitfld.long 0x00 24. " AC12E ,Auto CMD12 Error: Occurs when detecting that one of the bits in the Auto CMD12 Error Status register has changed from 0 to 1." "0,1"
        textline "          "
        bitfld.long 0x00 26. " TNE ,Tuning Error: (only for SD3.0 SDR104 mode) This bit is set when an unrecoverable error is detected in a tuning circuit." "0,1"
        textline "          "
        bitfld.long 0x00 28. " DMAE ,DMA Error: Occurs when an Internal DMA transfer has failed." "0,1"
width 14.
group.long 0x34++0x3
    line.long 0x00 "INT_STATUS_EN,Interrupt Status Enable"
        bitfld.long 0x00 0. " CCSEN ,Command Complete Status Enable: 1 Enabled 0 Masked" "0,1"
        textline "             "
        bitfld.long 0x00 1. " TCSEN ,Transfer Complete Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 2. " BGESEN ,Block Gap Event Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 3. " DINTSEN ,DMA Interrupt Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 4. " BWRSEN ,Buffer Write Ready Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 5. " BRRSEN ,Buffer Read Ready Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 6. " CINSSEN ,Card Insertion Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 7. " CRMSEN ,Card Removal Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 8. " CINTSEN ,Card Interrupt Status Enable: If this bit is set to 0, the uSDHC will clear the interrupt request to the System." "0,1"
        textline "             "
        bitfld.long 0x00 12. " RTESEN ,Re-Tuning Event Status Enable" "0,1"
        textline "             "
        bitfld.long 0x00 14. " TPSEN ,Tuning Pass Status Enable" "0,1"
        textline "             "
        bitfld.long 0x00 16. " CTOESEN ,Command Timeout Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 17. " CCESEN ,Command CRC Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 18. " CEBESEN ,Command End Bit Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 19. " CIESEN ,Command Index Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 20. " DTOESEN ,Data Timeout Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 21. " DCESEN ,Data CRC Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 22. " DEBESEN ,Data End Bit Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 24. " AC12ESEN ,Auto CMD12 Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 26. " TNESEN ,Tuning Error Status Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 28. " DMAESEN ,DMA Error Status Enable:" "0,1"
width 14.
group.long 0x38++0x3
    line.long 0x00 "INT_SIGNAL_EN,Interrupt Signal Enable"
        bitfld.long 0x00 0. " CCIEN ,Command Complete Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 1. " TCIEN ,Transfer Complete Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 2. " BGEIEN ,Block Gap Event Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 3. " DINTIEN ,DMA Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 4. " BWRIEN ,Buffer Write Ready Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 5. " BRRIEN ,Buffer Read Ready Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 6. " CINSIEN ,Card Insertion Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 7. " CRMIEN ,Card Removal Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 8. " CINTIEN ,Card Interrupt Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 12. " RTEIEN ,Re-Tuning Event Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 14. " TPIEN ,Tuning Pass Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 16. " CTOEIEN ,Command Timeout Error Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 17. " CCEIEN ,Command CRC Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 18. " CEBEIEN ,Command End Bit Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 19. " CIEIEN ,Command Index Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 20. " DTOEIEN ,Data Timeout Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 21. " DCEIEN ,Data CRC Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 22. " DEBEIEN ,Data End Bit Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 24. " AC12EIEN ,Auto CMD12 Error Interrupt Enable:" "0,1"
        textline "             "
        bitfld.long 0x00 26. " TNEIEN ,Tuning Error Interrupt Enable" "0,1"
        textline "             "
        bitfld.long 0x00 28. " DMAEIEN ,DMA Error Interrupt Enable:" "0,1"
width 21.
rgroup.long 0x3c++0x3
    line.long 0x00 "AUTOCMD12_ERR_STATUS,Auto CMD12 Error Status"
        bitfld.long 0x00 0. " AC12NE ,Auto CMD12 Not Executed: If memory multiple block data transfer is not started, due to a command error, this bit is not set because it is not necessary to issue an Auto CMD12." "0,1"
        textline "                    "
        bitfld.long 0x00 1. " AC12TOE ,Auto CMD12 Timeout Error: Occurs if no response is returned within 64 SDCLK cycles from the end bit of the command." "0,1"
        textline "                    "
        bitfld.long 0x00 2. " AC12EBE ,Auto CMD12 End Bit Error: Occurs when detecting that the end bit of command response is 0 which should be 1." "0,1"
        textline "                    "
        bitfld.long 0x00 3. " AC12CE ,Auto CMD12 CRC Error: Occurs when detecting a CRC error in the command response." "0,1"
        textline "                    "
        bitfld.long 0x00 4. " AC12IE ,Auto CMD12 Index Error: Occurs if the Command Index error occurs in response to a command." "0,1"
        textline "                    "
        bitfld.long 0x00 7. " CNIBAC12E ,Command Not Issued By Auto CMD12 Error: Setting this bit to 1 means CMD_wo_DAT is not executed due to an Auto CMD12 Error (D04-D01) in this register." "0,1"
        textline "                    "
        bitfld.long 0x00 22. " EXECUTE_TUNING ,Execute Tuning: When std_tuning_en bit is set, this bit is used to start tuning procedure." "0,1"
        textline "                    "
        bitfld.long 0x00 23. " SMP_CLK_SEL ,Sample Clock Select: When std_tuning_en bit is set, this bit is used to select sampling clock to receive CMD and DAT." "0,1"
width 14.
rgroup.long 0x40++0x3
    line.long 0x00 "HOST_CTRL_CAP,Host Controller Capabilities"
        bitfld.long 0x00 0. " SDR50_SUPPORT ,SDR50 support: This bit indicates support of SDR50 mode." "0,1"
        textline "             "
        bitfld.long 0x00 1. " SDR104_SUPPORT ,SDR104 support: This bit indicates support of SDR104 mode." "0,1"
        textline "             "
        bitfld.long 0x00 2. " DDR50_SUPPORT ,DDR50 support: This bit indicates support of DDR50 mode." "0,1"
        textline "             "
        hexmask.long.byte 0x00 8.--12. 1. " TIME_COUNT_RETUNING ,Time counter for retuning: This bit indicates an initial value of the Retuning Timer for Re-Tuning Mode1 and 3.Setting to 0 disables Retuning Timer."
        textline "             "
        bitfld.long 0x00 13. " USE_TUNING_SDR50 ,Use Tuning for SDR50: This bit is set to 1." "0,1"
        textline "             "
        hexmask.long.byte 0x00 14.--16. 1. " RETUNING_MODE ,Retuning Mode: This bit selects retuning method."
        textline "             "
        hexmask.long.byte 0x00 16.--19. 1. " MBL ,Max Block Length: This value indicates the maximum block size that the Host Driver can read and write to the buffer in the uSDHC."
        textline "             "
        bitfld.long 0x00 20. " ADMAS ,ADMA Support: This bit indicates whether the uSDHC supports the ADMA feature." "0,1"
        textline "             "
        bitfld.long 0x00 21. " HSS ,High Speed Support: This bit indicates whether the uSDHC supports High Speed mode and the Host System can supply a SD Clock frequency from 25 MHz to 50 MHz." "0,1"
        textline "             "
        bitfld.long 0x00 22. " DMAS ,DMA Support: This bit indicates whether the uSDHC is capable of using the internal DMA to transfer data between system memory and the data buffer directly." "0,1"
        textline "             "
        bitfld.long 0x00 23. " SRS ,Suspend / Resume Support: This bit indicates whether the uSDHC supports Suspend / Resume functionality." "0,1"
        textline "             "
        bitfld.long 0x00 24. " VS33 ,Voltage Support 3.3V: This bit shall depend on the Host System ability." "0,1"
        textline "             "
        bitfld.long 0x00 25. " VS30 ,Voltage Support 3.0V: This bit shall depend on the Host System ability." "0,1"
        textline "             "
        bitfld.long 0x00 26. " VS18 ,Voltage Support 1.8V: This bit shall depend on the Host System ability." "0,1"
width 9.
group.long 0x44++0x3
    line.long 0x00 "WTMK_LVL,Watermark Level"
        hexmask.long.byte 0x00 0.--8. 1. " RD_WML ,Read Watermark Level: The number of words used as the watermark level (FIFO threshold) in a DMA read operation."
        textline "        "
        hexmask.long.byte 0x00 8.--13. 1. " RD_BRST_LEN ,Read Burst Length: Due to system restriction, the actual burst length may not exceed 16."
        textline "        "
        hexmask.long.byte 0x00 16.--24. 1. " WR_WML ,Write Watermark Level: The number of words used as the watermark level (FIFO threshold) in a DMA write operation."
        textline "        "
        hexmask.long.byte 0x00 24.--29. 1. " WR_BRST_LEN ,Write Burst Length: Due to system restriction, the actual burst length may not exceed 16."
width 9.
group.long 0x48++0x3
    line.long 0x00 "MIX_CTRL,Mixer Control"
        bitfld.long 0x00 0. " DMAEN ,DMA Enable: This bit enables DMA functionality." "0,1"
        textline "        "
        bitfld.long 0x00 1. " BCEN ,Block Count Enable: This bit is used to enable the Block Count register, which is only relevant for multiple block transfers." "0,1"
        textline "        "
        bitfld.long 0x00 2. " AC12EN ,Auto CMD12 Enable: Multiple block transfers for memory require a CMD12 to stop the transaction." "0,1"
        textline "        "
        bitfld.long 0x00 3. " DDR_EN ,Dual Data Rate mode selection" "0,1"
        textline "        "
        bitfld.long 0x00 4. " DTDSEL ,Data Transfer Direction Select: This bit defines the direction of DAT line data transfers." "0,1"
        textline "        "
        bitfld.long 0x00 5. " MSBSEL ,Multi / Single Block Select: This bit enables multiple block DAT line data transfers." "0,1"
        textline "        "
        bitfld.long 0x00 6. " NIBBLE_POS ,In DDR 4-bit mode nibble position indictation." "0,1"
        textline "        "
        bitfld.long 0x00 7. " AC23EN ,Auto CMD23 Enable When this bit is set to 1, the Host Controller issues a CMD23 automatically before issuing a command specified in the Command Register." "0,1"
        textline "        "
        bitfld.long 0x00 22. " EXE_TUNE ,Execute Tuning: (Only used for SD3.0, SDR104 mode) When std_tuning_en is 0, this bit is set to 1 to indicate the Host Driver is starting tuning procedure." "0,1"
        textline "        "
        bitfld.long 0x00 23. " SMP_CLK_SEL ,When std_tuning_en is 0, this bit is used to select Tuned clock or Fixed clock to sample data/cmd (Only used for SD3.0, SDR104 mode)" "0,1"
        textline "        "
        bitfld.long 0x00 24. " AUTO_TUNE_EN ,Auto tuning enable (Only used for SD3.0, SDR104 mode)" "0,1"
        textline "        "
        bitfld.long 0x00 25. " FBCLK_SEL ,Feedback clock source selection (Only used for SD3.0, SDR104 mode)" "0,1"
width 12.
wgroup.long 0x50++0x3
    line.long 0x00 "FORCE_EVENT,Force Event"
        bitfld.long 0x00 0. " FEVTAC12NE ,Force Event Auto Command 12 Not Executed: Forces the AC12NE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 1. " FEVTAC12TOE ,Force Event Auto Command 12 Time Out Error: Forces the AC12TOE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 2. " FEVTAC12CE ,Force Event Auto Command 12 CRC Error: Forces the AC12CE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 3. " FEVTAC12EBE ,Force Event Auto Command 12 End Bit Error: Forces the AC12EBE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 4. " FEVTAC12IE ,Force Event Auto Command 12 Index Error: Forces the AC12IE bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 7. " FEVTCNIBAC12E ,Force Event Command Not Executed By Auto Command 12 Error: Forces the CNIBAC12E bit in the Auto Command12 Error Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 16. " FEVTCTOE ,Force Event Command Time Out Error: Forces the CTOE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 17. " FEVTCCE ,Force Event Command CRC Error: Forces the CCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 18. " FEVTCEBE ,Force Event Command End Bit Error: Forces the CEBE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 19. " FEVTCIE ,Force Event Command Index Error: Forces the CCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 20. " FEVTDTOE ,Force Event Data Time Out Error: Force the DTOE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 21. " FEVTDCE ,Force Event Data CRC Error: Forces the DCE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 22. " FEVTDEBE ,Force Event Data End Bit Error: Forces the DEBE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 24. " FEVTAC12E ,Force Event Auto Command 12 Error: Forces the AC12E bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 26. " FEVTTNE ,Force Tuning Error: Forces the TNE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 28. " FEVTDMAE ,Force Event DMA Error: Forces the DMAE bit of Interrupt Status Register to be set" "0,1"
        textline "           "
        bitfld.long 0x00 31. " FEVTCINT ,Force Event Card Interrupt: Writing 1 to this bit generates a short low-level pulse on the internal DAT[1] line, as if a self clearing interrupt was received from the external card." "0,1"
width 16.
rgroup.long 0x54++0x3
    line.long 0x00 "ADMA_ERR_STATUS,ADMA Error Status Register"
        hexmask.long.byte 0x00 0.--2. 1. " ADMAES ,ADMA Error State (when ADMA Error is occurred.): This field indicates the state of the ADMA when an error has occurred during an ADMA data transfer."
        textline "               "
        bitfld.long 0x00 2. " ADMALME ,ADMA Length Mismatch Error: This error occurs in the following 2 cases: While the Block Count Enable is being set, the total data length specified by the Descriptor table is different from that specified by the Block Count and Block Length Total data length can not be divided by the block length" "0,1"
        textline "               "
        bitfld.long 0x00 3. " ADMADCE ,ADMA Descritor Error: This error occurs when invalid descriptor fetched by ADMA:" "0,1"
width 14.
group.long 0x58++0x3
    line.long 0x00 "ADMA_SYS_ADDR,ADMA System Address"
        hexmask.long.long 0x00 2.--32. 1. " ADS_ADDR ,ADMA System Address: This register holds the word address of the executing command in the Descriptor table."
width 9.
group.long 0x60++0x3
    line.long 0x00 "DLL_CTRL,DLL (Delay Line) Control"
        bitfld.long 0x00 0. " DLL_CTRL_ENABLE ,Set this bit to 1 to enable the DLL and delay chain; otherwise; set to 0 to bypasses DLL." "0,1"
        textline "        "
        bitfld.long 0x00 1. " DLL_CTRL_RESET ,Setting this bit to 1 force a reset on DLL." "0,1"
        textline "        "
        bitfld.long 0x00 2. " DLL_CTRL_SLV_FORCE_UPD ,Setting this bit to 1, forces the slave delay line to update to the DLL calibrated value immediately." "0,1"
        textline "        "
        hexmask.long.byte 0x00 3.--7. 1. " DLL_CTRL_SLV_DLY_TARGET0 ,The delay target for the uSDHC loopback read clock can be programmed in 1/16th increments of an ref_clock half-period."
        textline "        "
        bitfld.long 0x00 7. " DLL_CTRL_GATE_UPDATE ,Set this bit to 1 to prevent the DLL from updating (since when clock_in exists, glitches may appear during DLL updates)." "0,1"
        textline "        "
        bitfld.long 0x00 8. " DLL_CTRL_SLV_OVERRIDE ,Set this bit to 1 to Enable manual override for slave delay chain using SLV_OVERRIDE_VAL; to set 0 to disable manual override." "0,1"
        textline "        "
        hexmask.long.byte 0x00 9.--16. 1. " DLL_CTRL_SLV_OVERRIDE_VAL ,When SLV_OVERRIDE=1 This field is used to select 1 of 128 physical taps manually."
        textline "        "
        hexmask.long.byte 0x00 16.--19. 1. " DLL_CTRL_SLV_DLY_TARGET1 ,Refer to DLL_CTRL_SLV_DLY_TARGET0 below."
        textline "        "
        hexmask.long.byte 0x00 20.--28. 1. " DLL_CTRL_SLV_UPDATE_INT ,Slave delay line update interval."
        textline "        "
        hexmask.long.byte 0x00 28.--32. 1. " DLL_CTRL_REF_UPDATE_INT ,DLL control loop update interval."
width 11.
rgroup.long 0x64++0x3
    line.long 0x00 "DLL_STATUS,DLL Status"
        bitfld.long 0x00 0. " DLL_STS_SLV_LOCK ,Slave delay-line lock status." "0,1"
        textline "          "
        bitfld.long 0x00 1. " DLL_STS_REF_LOCK ,Reference DLL lock status." "0,1"
        textline "          "
        hexmask.long.byte 0x00 2.--9. 1. " DLL_STS_SLV_SEL ,Slave delay line select status."
        textline "          "
        hexmask.long.byte 0x00 9.--16. 1. " DLL_STS_REF_SEL ,Reference delay line select taps."
width 21.
group.long 0x68++0x3
    line.long 0x00 "CLK_TUNE_CTRL_STATUS,CLK Tuning Control and Status"
        hexmask.long.byte 0x00 0.--4. 1. " DLY_CELL_SET_POST ,Set the number of delay cells on the feedback clock between CLK_OUT and CLK_POST."
        textline "                    "
        hexmask.long.byte 0x00 4.--8. 1. " DLY_CELL_SET_OUT ,Set the number of delay cells on the feedback clock between CLK_PRE and CLK_OUT."
        textline "                    "
        hexmask.long.byte 0x00 8.--15. 1. " DLY_CELL_SET_PRE ,Set the number of delay cells on the feedback clock between the feedback clock and CLK_PRE."
        textline "                    "
        bitfld.long 0x00 15. " NXT_ERR ,NXT error which means the number of delay cells added on the feedback clock is too large." "0,1"
        textline "                    "
        hexmask.long.byte 0x00 16.--20. 1. " TAP_SEL_POST ,Reflect the number of delay cells added on the feedback clock between CLK_OUT and CLK_POST."
        textline "                    "
        hexmask.long.byte 0x00 20.--24. 1. " TAP_SEL_OUT ,Reflect the number of delay cells added on the feedback clock between CLK_PRE and CLK_OUT."
        textline "                    "
        hexmask.long.byte 0x00 24.--31. 1. " TAP_SEL_PRE ,Reflects the number of delay cells added on the feedback clock between the feedback clock and CLK_PRE."
        textline "                    "
        bitfld.long 0x00 31. " PRE_ERR ,PRE error which means the number of delay cells added on the feedback clock is too small." "0,1"
width 10.
group.long 0xc0++0x3
    line.long 0x00 "VEND_SPEC,Vendor Specific Register"
        bitfld.long 0x00 0. " EXT_DMA_EN ,External DMA Request Enable Enable the request to external DMA." "0,1"
        textline "         "
        bitfld.long 0x00 1. " VSELECT ,Voltage Selection Change the value of output signal VSELECT, to control the voltage on pads for external card." "0,1"
        textline "         "
        bitfld.long 0x00 2. " CONFLICT_CHK_EN ,It's not implemented in uSDHC IP." "0,1"
        textline "         "
        bitfld.long 0x00 3. " AC12_WR_CHKBUSY_EN ,Check busy enable after auto CMD12 for write data packet" "0,1"
        textline "         "
        bitfld.long 0x00 4. " DAT3_CD_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 5. " CD_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 6. " WP_POL ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 7. " CLKONJ_IN_ABORT ,Only for debug." "0,1"
        textline "         "
        bitfld.long 0x00 8. " FRC_SDCLK_ON ,Force CLK output active:" "0,1"
        textline "         "
        bitfld.long 0x00 11. " IPG_CLK_SOFT_EN ,IPG_CLK software enable" "0,1"
        textline "         "
        bitfld.long 0x00 12. " HCLK_SOFT_EN ,Please note, hardware auto-enables the AHB clock when the internal DMA is enabled even if HCLK_SOFT_EN is 0." "0,1"
        textline "         "
        bitfld.long 0x00 13. " IPG_PERCLK_SOFT_EN ,ipg_perclk software enable" "0,1"
        textline "         "
        bitfld.long 0x00 14. " CARD_CLK_SOFT_EN ,card clock software enable" "0,1"
        textline "         "
        bitfld.long 0x00 15. " CRC_CHK_DIS ,CRC check disable" "0,1"
        textline "         "
        hexmask.long.byte 0x00 16.--24. 1. " INT_ST_VAL ,Internal State Value Internal state value, reflecting the corresponding state value selected by Debug Select field."
width 9.
group.long 0xc4++0x3
    line.long 0x00 "MMC_BOOT,MMC Boot Register"
        hexmask.long.byte 0x00 0.--4. 1. " DTOCV_ACK ,Boot ACK time out counter value."
        textline "        "
        bitfld.long 0x00 4. " BOOT_ACK ,Boot ack mode select." "0,1"
        textline "        "
        bitfld.long 0x00 5. " BOOT_MODE ,Boot mode select." "0,1"
        textline "        "
        bitfld.long 0x00 6. " BOOT_EN ,Boot mode enable." "0,1"
        textline "        "
        bitfld.long 0x00 7. " AUTO_SABG_EN ,During boot, enable auto stop at block gap function." "0,1"
        textline "        "
        bitfld.long 0x00 8. " DISABLE_TIME_OUT ,Please note, when this bit is set, there is no timeout check no matter whether boot_en is set or not." "0,1"
        textline "        "
        hexmask.long.word 0x00 16.--32. 1. " BOOT_BLK_CNT ,The value defines the Stop At Block Gap value of automatic mode."
width 11.
group.long 0xc8++0x3
    line.long 0x00 "VEND_SPEC2,Vendor Specific 2 Register"
        bitfld.long 0x00 0. " SDR104_TIMING_DIS ,Timeout counter test." "0,1"
        textline "          "
        bitfld.long 0x00 1. " SDR104_OE_DIS ,CMD_OE/DAT_OE logic generation test." "0,1"
        textline "          "
        bitfld.long 0x00 2. " SDR104_NSD_DIS ,Interrupt window after abort command is sent." "0,1"
        textline "          "
        bitfld.long 0x00 3. " CARD_INT_D3_TEST ,Card interrupt detection test." "0,1"
        textline "          "
        bitfld.long 0x00 4. " TUNING_8BIT_EN ,Enable the auto tuning circuit to check the DAT[7:0]." "0,1"
        textline "          "
        bitfld.long 0x00 5. " TUNING_1BIT_EN ,Enable the auto tuning circuit to check the DAT0 only." "0,1"
        textline "          "
        bitfld.long 0x00 6. " TUNING_CMD_EN ,Enable the auto tuning circuit to check the CMD line." "0,1"
        textline "          "
        bitfld.long 0x00 7. " CARD_INT_AUTO_CLR_DIS ,Disable the feature to clear the Card interrupt status bit when Card Interrupt status enable bit is cleared." "0,1"
width 12.
group.long 0xcc++0x3
    line.long 0x00 "TUNING_CTRL,Tuning Control Register"
        hexmask.long.byte 0x00 0.--8. 1. " TUNING_START_TAP ,The start dealy cell point when send first CMD19 in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 8.--16. 1. " TUNING_COUNTER ,The MAX repeat CMD19 times in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 16.--19. 1. " TUNING_STEP ,The increasing delay cell step in tuning procedure."
        textline "           "
        hexmask.long.byte 0x00 20.--23. 1. " TUNING_WINDOW ,Select data window value for auto tuning"
        textline "           "
        bitfld.long 0x00 24. " STD_TUNING_EN ,Standard tuning circuit and procedure enable: This bit is used to enable standard tuning circuit and procedure." "0,1"


    tree.end

tree.end



;--------------------------------------------------------------------------------
; WDOG
;--------------------------------------------------------------------------------
tree.open "WDOG"
    tree "WDOG1"
        base ad:0x020bc000

width 4.
group.word 0x0++0x1
    line.word 0x00 "WCR,Watchdog Control Register"
        bitfld.word 0x00 0. " WDZST ,Watchdog Low Power." "0,1"
        textline "   "
        bitfld.word 0x00 1. " WDBG ,Watchdog DEBUG Enable." "0,1"
        textline "   "
        bitfld.word 0x00 2. " WDE ,Watchdog Enable." "0,1"
        textline "   "
        bitfld.word 0x00 3. " WDT ,WDOG Time-out assertion." "0,1"
        textline "   "
        bitfld.word 0x00 4. " SRS ,Software Reset Signal." "0,1"
        textline "   "
        bitfld.word 0x00 5. " WDA ,WDOG assertion." "0,1"
        textline "   "
        bitfld.word 0x00 6. " SRE ,adopt a new way to generate a more robust software reset." "0,1"
        textline "   "
        bitfld.word 0x00 7. " WDW ,Watchdog Disable for Wait." "0,1"
        textline "   "
        hexmask.word.byte 0x00 8.--16. 1. " WT ,Watchdog Time-out Field."
width 4.
group.word 0x2++0x1
    line.word 0x00 "WSR,Watchdog Service Register"
        hexmask.word.word 0x00 0.--16. 1. " WSR ,Watchdog Service Register."
width 5.
rgroup.word 0x4++0x1
    line.word 0x00 "WRSR,Watchdog Reset Status Register"
        bitfld.word 0x00 0. " SFTW ,Software Reset." "0,1"
        textline "    "
        bitfld.word 0x00 1. " TOUT ,Timeout." "0,1"
        textline "    "
        bitfld.word 0x00 4. " POR ,Power On Reset." "0,1"
width 5.
group.word 0x6++0x1
    line.word 0x00 "WICR,Watchdog Interrupt Control Register"
        hexmask.word.byte 0x00 0.--8. 1. " WICT ,Watchdog Interrupt Count Time-out (WICT) field determines, how long before the counter time-out must the interrupt occur."
        textline "    "
        bitfld.word 0x00 14. " WTIS ,Watchdog TImer Interrupt Status bit will reflect the timer interrupt status, whether interrupt has occurred or not." "0,1"
        textline "    "
        bitfld.word 0x00 15. " WIE ,Watchdog Timer Interrupt enable bit." "0,1"
width 5.
group.word 0x8++0x1
    line.word 0x00 "WMCR,Watchdog Miscellaneous Control Register"
        bitfld.word 0x00 0. " PDE ,Power Down Enable bit." "0,1"


    tree.end
    tree "WDOG2"
        base ad:0x020c0000

width 4.
group.word 0x0++0x1
    line.word 0x00 "WCR,Watchdog Control Register"
        bitfld.word 0x00 0. " WDZST ,Watchdog Low Power." "0,1"
        textline "   "
        bitfld.word 0x00 1. " WDBG ,Watchdog DEBUG Enable." "0,1"
        textline "   "
        bitfld.word 0x00 2. " WDE ,Watchdog Enable." "0,1"
        textline "   "
        bitfld.word 0x00 3. " WDT ,WDOG Time-out assertion." "0,1"
        textline "   "
        bitfld.word 0x00 4. " SRS ,Software Reset Signal." "0,1"
        textline "   "
        bitfld.word 0x00 5. " WDA ,WDOG assertion." "0,1"
        textline "   "
        bitfld.word 0x00 6. " SRE ,adopt a new way to generate a more robust software reset." "0,1"
        textline "   "
        bitfld.word 0x00 7. " WDW ,Watchdog Disable for Wait." "0,1"
        textline "   "
        hexmask.word.byte 0x00 8.--16. 1. " WT ,Watchdog Time-out Field."
width 4.
group.word 0x2++0x1
    line.word 0x00 "WSR,Watchdog Service Register"
        hexmask.word.word 0x00 0.--16. 1. " WSR ,Watchdog Service Register."
width 5.
rgroup.word 0x4++0x1
    line.word 0x00 "WRSR,Watchdog Reset Status Register"
        bitfld.word 0x00 0. " SFTW ,Software Reset." "0,1"
        textline "    "
        bitfld.word 0x00 1. " TOUT ,Timeout." "0,1"
        textline "    "
        bitfld.word 0x00 4. " POR ,Power On Reset." "0,1"
width 5.
group.word 0x6++0x1
    line.word 0x00 "WICR,Watchdog Interrupt Control Register"
        hexmask.word.byte 0x00 0.--8. 1. " WICT ,Watchdog Interrupt Count Time-out (WICT) field determines, how long before the counter time-out must the interrupt occur."
        textline "    "
        bitfld.word 0x00 14. " WTIS ,Watchdog TImer Interrupt Status bit will reflect the timer interrupt status, whether interrupt has occurred or not." "0,1"
        textline "    "
        bitfld.word 0x00 15. " WIE ,Watchdog Timer Interrupt enable bit." "0,1"
width 5.
group.word 0x8++0x1
    line.word 0x00 "WMCR,Watchdog Miscellaneous Control Register"
        bitfld.word 0x00 0. " PDE ,Power Down Enable bit." "0,1"


    tree.end

tree.end



;--------------------------------------------------------------------------------
; XTALOSC24M
;--------------------------------------------------------------------------------
tree "XTALOSC24M"
    base ad:0x020c8000

width 6.
group.long 0x150++0x3
    line.long 0x00 "MISC0,Miscellaneous Register 0"
        bitfld.long 0x00 0. " REFTOP_PWD ,Control bit to power-down the analog bandgap reference circuitry." "0,1"
        textline "     "
        bitfld.long 0x00 3. " REFTOP_SELFBIASOFF ,Control bit to disable the self-bias circuit in the analog bandgap." "0,1"
        textline "     "
        hexmask.long.byte 0x00 4.--7. 1. " REFTOP_VBGADJ ,Not related to oscillator."
        textline "     "
        bitfld.long 0x00 7. " REFTOP_VBGUP ,Status bit which signals that the analog bandgap voltage is up and stable." "0,1"
        textline "     "
        hexmask.long.byte 0x00 11.--13. 1. " STOP_MODE_CONFIG ,Configure the analog behavior in stop mode."
        textline "     "
        hexmask.long.byte 0x00 14.--16. 1. " OSC_I ,This bit field determines the bias current in the 24MHz oscillator."
        textline "     "
        bitfld.long 0x00 16. " OSC_XTALOK ,Status bit which signals that the output of the 24MHz crystal oscillator is stable." "0,1"
        textline "     "
        bitfld.long 0x00 17. " OSC_XTALOK_EN ,Enable bit for the xtal_ok module(24 MHz)" "0,1"
        textline "     "
        hexmask.long.byte 0x00 18.--20. 1. " WBCP_VPW_THRESH ,This signal alters the voltage that the pwell is charged pumped to."
        textline "     "
        bitfld.long 0x00 25. " CLKGATE_CTRL ,This bit allows disabling the clock gate (always un-gated) for the xtal 24MHz clock that clocks the digital logic in the analog block." "0,1"
        textline "     "
        hexmask.long.byte 0x00 26.--29. 1. " CLKGATE_DELAY ,This field specifies the delay between powering up the XTAL 24MHz clock and release the clock to the digital logic inside the analog block."
width 6.
group.long 0x260++0x3
    line.long 0x00 "MISC1,XTAL OSC MISC1 Control Register"
        bitfld.long 0x00 0. " RC_OSC_EN ,RC Osc." "0,1"
        textline "     "
        hexmask.long.byte 0x00 1.--4. 1. " RC_OSC_PROG ,RC osc."
        textline "     "
        bitfld.long 0x00 4. " OSC_SEL ,Select the source for the 24MHz clock." "0,1"
        textline "     "
        bitfld.long 0x00 5. " LPBG_SEL ,Bandgap select." "0,1"
        textline "     "
        bitfld.long 0x00 6. " LPBG_TEST ,Low power bandgap test bit." "0,1"
        textline "     "
        bitfld.long 0x00 7. " REFTOP_IBIAS_OFF ,Low power reftop ibias disable." "0,1"
        textline "     "
        bitfld.long 0x00 8. " L1_PWRGATE ,L1 power gate control." "0,1"
        textline "     "
        bitfld.long 0x00 9. " L2_PWRGATE ,L2 power gate control." "0,1"
        textline "     "
        bitfld.long 0x00 10. " CPU_PWRGATE ,CPU power gate control." "0,1"
        textline "     "
        bitfld.long 0x00 11. " DISPLAY_PWRGATE ,Display logic power gate control." "0,1"
        textline "     "
        bitfld.long 0x00 12. " RWB_EN ,Reverse well bias enable control." "0,1"
        textline "     "
        bitfld.long 0x00 13. " RCOSC_CG_OVERRIDE ,For debug purposes only." "0,1"
        textline "     "
        hexmask.long.byte 0x00 14.--16. 1. " XTALOSC_PWRUP_DELAY ,Specifies the time delay between when the 24MHz xtal is powered up until it is stable and ready to use."
        textline "     "
        bitfld.long 0x00 16. " XTALOSC_PWRUP_STAT ,Status of the 24MHz xtal oscillator." "0,1"


tree.end


