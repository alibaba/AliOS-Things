# Keil uVision project boot_pca10056.uvprojx, settings and files
target nrf52840_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA
  c misc: --reduce_paths --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_pca10056\" -DSYSINFO_DEVICE_NAME=\"pca10056\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.3.3\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\..\..\..\platform\mcu\pca10056\src\pca10056\base_pro\;..\..\..\..\platform\mcu\pca10056\Drivers;..\..\..\..\platform\mcu\pca10056\Drivers\boards;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\clock;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\common;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\gpiote;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\hal;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\nrf_soc_nosd;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\atomic;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\balloc;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\bsp;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\button;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_log;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_log\src;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_memobj;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_section_vars;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\strerror;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\timer;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\util;..\..\..\..\platform\mcu\pca10056\Drivers\toolchain;..\..\..\..\platform\arch\arm\armv7m\armcc\m4\;..\..\..\..\board\pca10056\;..\..\..\..\include;..\..\..\..\kernel\rhino\core\include;..\..\..\..\include\hal;..\..\..\..\kernel\vcall\aos;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\delay\;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\systick;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\uart;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\fifo;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\uart;..\..\..\..\platform\mcu\pca10056\Drivers\boards
  asm define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  NRF52840_XXAA
  asm misc: --cpreproc_opts=-DBOARD_pca10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DFREERTOS,-DNRF52,-DNRF52840_XXAA,-DNRF52_PAN_74
  asm include: ..\..\..\config;..\..\..\..\platform\mcu\pca10056\Drivers;..\..\..\..\platform\mcu\pca10056\Drivers\boards;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\clock;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\common;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\gpiote;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\hal;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\nrf_soc_nosd;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\atomic;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\balloc;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\bsp;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\button;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_log;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_log\src;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_memobj;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_section_vars;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\strerror;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\timer;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\util;..\..\..\..\platform\mcu\pca10056\Drivers\toolchain;..\..\..;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../../../platform/mcu/pca10056/src/pca10056/base_pro/: sdk_config.h
    ../../../../example/pca_helloworld/: boot.c
    ./: ota_helper.c ota_helper.h
  group Board Definition
    ../../../../platform/mcu/pca10056/Drivers/boards/: boards.c
  group Board Support
    ../../../../platform/mcu/pca10056/Drivers/libraries/bsp/: bsp.c
  group nRF_Drivers
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/common/: nrf_drv_common.c
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/systick/: nrf_drv_systick.c
    ../../../../platform/mcu/pca10056/Drivers/device/: nrf52840.h nrf52840_bitfields.h
    ../../../../platform/mcu/pca10056/Drivers/libraries/bootloader/dfu/: nrf_dfu_types.h
  group nRF_Libraries
    ../../../../platform/mcu/pca10056/Drivers/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/balloc/: nrf_balloc.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/strerror/: nrf_strerror.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/button/: app_button.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/timer/: app_timer.c
  group nRF_Log
    ../../../../platform/mcu/pca10056/Drivers/libraries/experimental_log/src/: nrf_log_frontend.c
  group aos
    ../../../../platform/mcu/pca10056/aos/: trace_impl.c
  group boot
    ../../../../platform/mcu/pca10056/src/pca10056/boot/: arm_boot_nrf52840.s system_nrf52840.c
  group uart
    ../../../../platform/mcu/pca10056/src/pca10056/boot/: app_uart_fifo.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/fifo/: app_fifo.c
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/uart/: nrf_drv_uart.c
software components: CMSIS:CORE 4.3.0
