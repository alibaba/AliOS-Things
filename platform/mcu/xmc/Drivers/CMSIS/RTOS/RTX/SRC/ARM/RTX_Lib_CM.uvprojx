# Keil uVision project RTX_Lib_CM.uvprojx, settings and files
target CM0_LE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM0 (library)
  AfterMake: cmd.exe /C copy CM0_LE\RTX_CM0.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M0 __CMSIS_RTOS
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Kernel
    ../: rt_CMSIS.c rt_Task.c rt_System.c rt_Event.c rt_List.c rt_Mailbox.c rt_Semaphore.c rt_Time.c rt_Timer.c rt_Mutex.c rt_Robin.c rt_MemBox.c rt_Memory.c
  group HAL
    ./: SVC_Table.s HAL_CM0.c HAL_CM3.c HAL_CM4.c
    ../: HAL_CM.c
target CM0_BE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM0_B (library)
  AfterMake: cmd.exe /C copy CM0_BE\RTX_CM0_B.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M0 __CMSIS_RTOS
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM3_LE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM3 (library)
  AfterMake: cmd.exe /C copy CM3_LE\RTX_CM3.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M3 __CMSIS_RTOS DBG_MSG
  c misc: --diag_suppress 3731
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM3_BE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM3_B (library)
  AfterMake: cmd.exe /C copy CM3_BE\RTX_CM3_B.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M3 __CMSIS_RTOS DBG_MSG
  c misc: --diag_suppress 3731
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM3_LE_IFX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM3_IFX (library)
  AfterMake: cmd.exe /C copy CM3_LE_IFX\RTX_CM3_IFX.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M3 __CMSIS_RTOS DBG_MSG
  c misc: --diag_suppress 3731
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM3X_LE (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM3X (library)
  AfterMake: cmd.exe /C copy CM3X_LE\RTX_CM3X.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M3 __CMSIS_RTOS DBG_MSG NO_EXCLUSIVE_ACCESS
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM4F_LE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM4 (library)
  AfterMake: cmd.exe /C copy CM4F_LE\RTX_CM4.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M4F __FPU_PRESENT=1 __CMSIS_RTOS DBG_MSG
  c misc: --diag_suppress 3731
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM4F_BE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM4_B (library)
  AfterMake: cmd.exe /C copy CM4F_BE\RTX_CM4_B.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M4F __FPU_PRESENT=1 __CMSIS_RTOS DBG_MSG
  c misc: --diag_suppress 3731
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM4F_LE_IFX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM4_IFX (library)
  AfterMake: cmd.exe /C copy CM4F_LE_IFX\RTX_CM4_IFX.lib ..\..\LIB\ARM
  c flags: Optim=4 OneElfS=1
  c define: __CORTEX_M4F __FPU_PRESENT=1 __CMSIS_RTOS DBG_MSG
  c misc: --diag_suppress 3731
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 4.1.0
