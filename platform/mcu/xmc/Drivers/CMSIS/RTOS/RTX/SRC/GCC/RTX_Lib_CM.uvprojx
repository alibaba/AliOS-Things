# Keil uVision project RTX_Lib_CM.uvprojx, settings and files
target CM0_LE (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM0 (library)
  AfterMake: cmd.exe /C copy CM0_LE\libRTX_CM0.a ..\..\LIB\GCC\
  group Kernel
    ../: rt_CMSIS.c rt_Task.c rt_System.c rt_Event.c rt_List.c rt_Mailbox.c rt_Semaphore.c rt_Time.c rt_Timer.c rt_Mutex.c rt_Robin.c rt_MemBox.c rt_Memory.c
  group HAL
    ./: SVC_Table.S HAL_CM0.S HAL_CM3.S HAL_CM4.S
    ../: HAL_CM.c
target CM0_BE (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM0_B (library)
  AfterMake: cmd.exe /C copy CM0_BE\libRTX_CM0_B.a ..\..\LIB\GCC\
target CM3_LE (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM3 (library)
  AfterMake: cmd.exe /C copy CM3_LE\libRTX_CM3.a ..\..\LIB\GCC\
target CM3_BE (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM3_B (library)
  AfterMake: cmd.exe /C copy CM3_BE\libRTX_CM3_B.a ..\..\LIB\GCC\
target CM3_LE_IFX (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM3_IFX (library)
  AfterMake: cmd.exe /C copy CM3_LE_IFX\libRTX_CM3_IFX.a ..\..\LIB\GCC\
target CM4F_LE (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM4 (library)
  AfterMake: cmd.exe /C copy CM4F_LE\libRTX_CM4.a ..\..\LIB\GCC\
target CM4F_BE (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM4_B (library)
  AfterMake: cmd.exe /C copy CM4F_BE\libRTX_CM4_B.a ..\..\LIB\GCC\
target CM4F_LE_IFX (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta13
  cpu: as above
  output: RTX_CM4_IFX (library)
  AfterMake: cmd.exe /C copy CM4F_LE_IFX\libRTX_CM4_IFX.a ..\..\LIB\GCC\
software components: CMSIS:CORE 4.1.0
