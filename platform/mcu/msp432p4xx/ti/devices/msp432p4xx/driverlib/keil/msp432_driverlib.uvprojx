# Keil uVision project msp432_driverlib.uvprojx, settings and files
target msp432_driverlib (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta4
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: msp432p4xx_driverlib (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ../../../../../;../../../../../third_party/CMSIS/Include/;../../../../../ti/devices/msp432p4xx/inc/
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Shared Peripherals
    ../: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group msp432p401
    ../: flash.c sysctl_a.c
  group msp432p4111
    ../: flash_a.c lcd_f.c sysctl_a.c
