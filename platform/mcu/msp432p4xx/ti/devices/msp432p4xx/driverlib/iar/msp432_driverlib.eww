<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\msp432_driverlib.ewp</path>
    </project>
    <batchBuild />
</workspace>
