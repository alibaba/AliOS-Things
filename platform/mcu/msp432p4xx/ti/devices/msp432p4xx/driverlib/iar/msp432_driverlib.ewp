# IAR project msp432_driverlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\third_party\CMSIS\Include; ..\..\inc; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: msp432_driverlib.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group msp432p401
    ../: flash.c sysctl.c
  group msp432p4111
    ../: flash_a.c lcd_f.c sysctl_a.c
  group Shared Peripherals
    ../: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c systick.c timer32.c timer_a.c uart.c wdt_a.c
