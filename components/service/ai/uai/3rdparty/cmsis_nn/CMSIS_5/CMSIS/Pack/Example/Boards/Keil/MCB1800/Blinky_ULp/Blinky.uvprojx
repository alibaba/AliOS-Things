# Keil uVision project Blinky.uvprojx, settings and files
target SWO Trace (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.6.0-dev1
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(180000000) ELITTLE
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: Blinky.c IRQ.c ITM_Retarget.c
  group Trace Configuration
    ./: LPC18xx_TP.ini
  group Documentation
    ./: Abstract.txt
target TracePort Trace (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.6.0-dev1
  cpu: as above
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Instruction Trace (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.6.0-dev1
  cpu: as above
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target Embedded Trace Buffer (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.6.0-dev1
  cpu: as above
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.30.0, Board Support:A/D Converter 1.0.0, Board Support:LED 1.0.0, Device:GPIO 1.00, Device:SCU 1.00, Device:Startup 1.0.0
