# Keil uVision project CMSIS_DAP.uvprojx, settings and files
target LPC4320 SPIFI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4320:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.8.0
  cpu: IRAM(0x10000000,0x18000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS_DAP
  c flags: Optim=4 uC99=1 wLevel=2
  c include: .;..\..\..\Include
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c USBD_User_CustomClass_0.c
  group Documentation
    ./: Abstract.txt
  group CMSIS DAP
    ../../../Source/: DAP.c JTAG_DP.c SW_DP.c SWO.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.2.3, USB:CORE 6.12.0, USB:Device 6.12.0, USB:Device:Custom Class 6.12.0, CMSIS Driver:USART 2.12, CMSIS Driver:USB Device:USB0 2.11, Device:GPDMA 1.5, Device:SCU 1.1, Device:Startup 1.0.0
