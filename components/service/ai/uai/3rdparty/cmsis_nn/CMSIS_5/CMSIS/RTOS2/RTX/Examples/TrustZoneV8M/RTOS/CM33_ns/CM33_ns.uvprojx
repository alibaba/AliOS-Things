# Keil uVision project CM33_ns.uvprojx, settings and files
target FVP Simulation Model (6120000::V6.12 for Armv8.1-M and MVE::.\ARMCLANG_MVE)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.5.2-dev5
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: CM33_ns
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\RTE\Device\ARMCM33_DSP_FP_TZ\ARMCM33_AC6.sct
  group Non-secure Code
    ./: main_ns.c
  group CMSE Library
    ../CM33_s/Objects/: CM33_s_CMSE_Lib.o
    ../CM33_s/: interface.h
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Device:Startup 2.0.0
