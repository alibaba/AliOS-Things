# Keil uVision project Template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTOS
  c flags: Optim=1 wLevel=2
  c include: ..\Template
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_LPC177x_8x.s system_LPC177x_8x.c os_sample.c os_sample1.c
  group CPP
    ./CPP/: Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group Documentation
    ../../DoxyGen/RTOS/src/: cmsis_os.txt
    ../../DoxyGen/RTOS/: doxygen_rtos.bat
    ../../DoxyGen/RTOS/html/: index.html
