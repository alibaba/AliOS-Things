# Keil uVision project Blinky.uvprojx, settings and files
target Simulation (6120000::V6.12 for Armv8.1-M and MVE::.\ARMCLANG_MVE)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.2-dev5
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS:Keil RTX5 5.5.1, CMSIS:RTOS2:Keil RTX5 5.5.1, Device:Startup 2.0.0, Compiler:I/O:STDOUT 1.2.0
