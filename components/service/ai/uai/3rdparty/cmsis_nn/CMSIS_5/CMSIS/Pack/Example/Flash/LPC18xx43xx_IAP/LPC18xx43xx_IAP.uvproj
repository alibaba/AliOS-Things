# Keil uVision project LPC18xx43xx_IAP.uvproj, settings and files
target LPC18xx43xx_512_BA (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC18xx43xx_512_BA
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC18xx43xx FLASH_512_BA
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target LPC18xx43xx_512_BB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC18xx43xx_512_BB
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC18xx43xx FLASH_512_BB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC18xx43xx_384_BA (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC18xx43xx_384_BA
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC18xx43xx FLASH_384_BA
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC18xx43xx_384_BB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC18xx43xx_384_BB
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC18xx43xx FLASH_384_BB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC18xx43xx_256_BA (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC18xx43xx_256_BA
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC18xx43xx FLASH_256_BA
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC18xx43xx_256_BB (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPC18xx43xx_256_BB
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: LPC18xx43xx FLASH_256_BB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
