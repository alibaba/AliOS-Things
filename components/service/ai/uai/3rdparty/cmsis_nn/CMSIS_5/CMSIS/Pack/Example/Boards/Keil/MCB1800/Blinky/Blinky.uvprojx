# Keil uVision project Blinky.uvprojx, settings and files
target LPC1857 Flash (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1857 NXP (founded by Philips)
  pack: Keil.LPC1800_DFP.2.6.0-dev1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC1857 RAM (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1857 NXP (founded by Philips)
  pack: Keil.LPC1800_DFP.2.6.0-dev1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC1857 Ext. Flash (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1857 NXP (founded by Philips)
  pack: Keil.LPC1800_DFP.2.6.0-dev1
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x1c000000 size 0x1000000
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC1857 SPIFI (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1857 NXP (founded by Philips)
  pack: Keil.LPC1800_DFP.2.6.0-dev1
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.30.0, Board Support:LED 1.00, Device:GPIO 1.00, Device:SCU 1.00, Device:Startup 1.0.0
