# Keil uVision project DspLibTest_MPS2.uvprojx, settings and files
target cortexM0l (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  group DSP_Lib Files
    ../../../Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../Source/CommonTables/: CommonTables.c
    ../../../Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../../Source/ControllerFunctions/: ControllerFunctions.c
    ../../../Source/FastMathFunctions/: FastMathFunctions.c
    ../../../Source/FilteringFunctions/: FilteringFunctions.c
    ../../../Source/MatrixFunctions/: MatrixFunctions.c
    ../../../Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../../Source/SupportFunctions/: SupportFunctions.c
    ../../../Source/TransformFunctions/: TransformFunctions.c
  group Ref_Lib Files
    ../../RefLibs/src/BasicMathFunctions/: BasicMathFunctions.c
    ../../RefLibs/src/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../RefLibs/src/ControllerFunctions/: ControllerFunctions.c
    ../../RefLibs/src/FastMathFunctions/: FastMathFunctions.c
    ../../RefLibs/src/FilteringFunctions/: FilteringFunctions.c
    ../../RefLibs/src/HelperFunctions/: HelperFunctions.c
    ../../RefLibs/src/Intrinsics/: Intrinsics_.c
    ../../RefLibs/src/MatrixFunctions/: MatrixFunctions.c
    ../../RefLibs/src/StatisticsFunctions/: StatisticsFunctions.c
    ../../RefLibs/src/SupportFunctions/: SupportFunctions.c
    ../../RefLibs/src/TransformFunctions/: TransformFunctions.c
  group Startup
    ../../Common/src/: main.c
    ../../Common/platform/: system_generic.c startup_generic.S
  group JTest
    ../../Common/JTest/src/: jtest_cycle.c jtest_fw.c jtest_dump_str_segments.c jtest_trigger_action.c
  group AllTests
    ../../Common/src/: all_tests.c
  group Transform
    ../../Common/src/transform_tests/: cfft_tests.c transform_test_group.c transform_tests_common_data.c cfft_family_tests.c rfft_tests.c rfft_fast_tests.c dct4_tests.c
  group BasicMath
    ../../Common/src/basic_math_tests/: basic_math_test_common_data.c abs_tests.c basic_math_test_group.c negate_tests.c add_tests.c mult_tests.c sub_tests.c dot_prod_tests.c offset_tests.c shift_tests.c scale_tests.c
  group ComplexMath
    ../../Common/src/complex_math_tests/: complex_math_test_group.c complex_math_test_common_data.c cmplx_conj_tests.c cmplx_mag_tests.c cmplx_mag_squared_tests.c cmplx_dot_prod_tests.c cmplx_mult_cmplx_tests.c cmplx_mult_real_test.c
  group Controller
    ../../Common/src/controller_tests/: controller_test_group.c pid_reset_tests.c sin_cos_tests.c pid_tests.c controller_test_common_data.c
  group FastMath
    ../../Common/src/fast_math_tests/: fast_math_tests.c fast_math_tests_common_data.c
  group Filtering
    ../../Common/src/filtering_tests/: filtering_test_common_data.c filtering_test_group.c biquad_tests.c conv_tests.c correlate_tests.c fir_tests.c iir_tests.c lms_tests.c
  group Matrix
    ../../Common/src/matrix_tests/: matrix_test_common_data.c matrix_test_group.c mat_cmplx_mult_tests.c mat_add_tests.c mat_mult_tests.c mat_mult_fast_tests.c mat_sub_tests.c mat_inverse_tests.c mat_trans_tests.c mat_init_tests.c mat_scale_tests.c
  group Statistics
    ../../Common/src/statistics_tests/: max_tests.c statistics_test_common_data.c statistics_test_group.c mean_tests.c min_tests.c power_tests.c rms_tests.c std_tests.c var_tests.c
  group Support
    ../../Common/src/support_tests/: copy_tests.c support_test_common_data.c support_test_group.c fill_tests.c x_to_y_tests.c
  group Intrinsics
    ../../Common/src/intrinsics_tests/: intrinsics_tests.c intrinsics_tests_common_data.c
  group MathHelper
    ../../Common/src/: math_helper.c
target cortexM3l (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target cortexM4l (ARM-GNU)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target cortexM4lf (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target cortexM7l (ARM-GNU)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target cortexM7lfsp (ARM-GNU)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target cortexM7lfdp (ARM-GNU)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target ARMv8MBLl (ARM-GNU)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target ARMv8MMLl (ARM-GNU)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target ARMv8MMLlfsp (ARM-GNU)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target ARMv8MMLld (ARM-GNU)
  device: ARMv8MML_DSP ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
target ARMv8MMLldfsp (ARM-GNU)
  device: ARMv8MML_DSP_SP ARM
  pack: ARM.CMSIS.5.5.0-dev52
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
