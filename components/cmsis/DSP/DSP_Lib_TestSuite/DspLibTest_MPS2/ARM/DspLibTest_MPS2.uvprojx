# Keil uVision project DspLibTest_MPS2.uvprojx, settings and files
target cortexM0l (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM0
  c include: ..\..\..\..\Core\Include;..\..\..\Include;..\..\..\..\..\Device\ARM\ARMCM0\Include;..\..\RefLibs\inc;..\..\Common\JTest\inc;..\..\Common\JTest\inc\arr_desc;..\..\Common\inc;..\..\Common\inc\templates;..\..\Common\inc\basic_math_tests;..\..\Common\inc\complex_math_tests;..\..\Common\inc\statistics_tests;..\..\Common\inc\matrix_tests;..\..\Common\inc\support_tests;..\..\Common\inc\controller_tests;..\..\Common\inc\transform_tests;..\..\Common\inc\fast_math_tests;..\..\Common\inc\filtering_tests;..\..\Common\inc\intrinsics_tests
  asm define: ARM_MATH_CM0
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Libraries
    ./Lib/: arm_math.lib arm_ref.lib
  group Startup
    ../../Common/src/: main.c
    ../../Common/platform/: system_generic.c startup_generic.S
  group JTest
    ../../Common/JTest/src/: jtest_cycle.c jtest_fw.c jtest_dump_str_segments.c jtest_trigger_action.c
  group AllTests
    ../../Common/src/: all_tests.c
  group Transform
    ../../Common/src/transform_tests/: cfft_tests.c transform_test_group.c transform_tests_common_data.c cfft_family_tests.c rfft_tests.c rfft_fast_tests.c dct4_tests.c
  group BasicMath
    ../../Common/src/basic_math_tests/: basic_math_test_common_data.c abs_tests.c basic_math_test_group.c negate_tests.c add_tests.c mult_tests.c sub_tests.c dot_prod_tests.c offset_tests.c shift_tests.c scale_tests.c
  group ComplexMath
    ../../Common/src/complex_math_tests/: complex_math_test_group.c complex_math_test_common_data.c cmplx_conj_tests.c cmplx_mag_tests.c cmplx_mag_squared_tests.c cmplx_dot_prod_tests.c cmplx_mult_cmplx_tests.c cmplx_mult_real_test.c
  group Controller
    ../../Common/src/controller_tests/: controller_test_group.c pid_reset_tests.c sin_cos_tests.c pid_tests.c controller_test_common_data.c
  group FastMath
    ../../Common/src/fast_math_tests/: fast_math_tests.c fast_math_tests_common_data.c
  group Filtering
    ../../Common/src/filtering_tests/: filtering_test_common_data.c filtering_test_group.c biquad_tests.c conv_tests.c correlate_tests.c fir_tests.c iir_tests.c lms_tests.c
  group Matrix
    ../../Common/src/matrix_tests/: matrix_test_common_data.c matrix_test_group.c mat_cmplx_mult_tests.c mat_add_tests.c mat_mult_tests.c mat_mult_fast_tests.c mat_sub_tests.c mat_inverse_tests.c mat_trans_tests.c mat_init_tests.c mat_scale_tests.c
  group Statistics
    ../../Common/src/statistics_tests/: max_tests.c statistics_test_common_data.c statistics_test_group.c mean_tests.c min_tests.c power_tests.c rms_tests.c std_tests.c var_tests.c
  group Support
    ../../Common/src/support_tests/: copy_tests.c support_test_common_data.c support_test_group.c fill_tests.c x_to_y_tests.c
  group Intrinsics
    ../../Common/src/intrinsics_tests/: intrinsics_tests.c intrinsics_tests_common_data.c
  group MathHelper
    ../../Common/src/: math_helper.c
target cortexM3l (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1 oTime=1 wLevel=2
  c define: ARM_MATH_CM3
  c include: ..\..\..\..\Core\Include;..\..\..\Include;..\..\..\..\..\Device\ARM\ARMCM3\Include;..\..\RefLibs\inc;..\..\Common\JTest\inc;..\..\Common\JTest\inc\arr_desc;..\..\Common\inc;..\..\Common\inc\templates;..\..\Common\inc\basic_math_tests;..\..\Common\inc\complex_math_tests;..\..\Common\inc\statistics_tests;..\..\Common\inc\matrix_tests;..\..\Common\inc\support_tests;..\..\Common\inc\controller_tests;..\..\Common\inc\transform_tests;..\..\Common\inc\fast_math_tests;..\..\Common\inc\filtering_tests;..\..\Common\inc\intrinsics_tests
  asm define: ARM_MATH_CM3
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4l (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1 oTime=1 wLevel=2
  c define: ARM_MATH_CM4
  c include: ..\..\..\..\Core\Include;..\..\..\Include;..\..\..\..\..\Device\ARM\ARMCM4\Include;..\..\RefLibs\inc;..\..\Common\JTest\inc;..\..\Common\JTest\inc\arr_desc;..\..\Common\inc;..\..\Common\inc\templates;..\..\Common\inc\basic_math_tests;..\..\Common\inc\complex_math_tests;..\..\Common\inc\statistics_tests;..\..\Common\inc\matrix_tests;..\..\Common\inc\support_tests;..\..\Common\inc\controller_tests;..\..\Common\inc\transform_tests;..\..\Common\inc\fast_math_tests;..\..\Common\inc\filtering_tests;..\..\Common\inc\intrinsics_tests
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4lf (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM4 __FPU_PRESENT=1U
  c include: as above
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7l (ARM-ADS)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1 oTime=1 wLevel=2
  c define: ARM_MATH_CM7
  c include: ..\..\..\..\Core\Include;..\..\..\Include;..\..\..\..\..\Device\ARM\ARMCM7\Include;..\..\RefLibs\inc;..\..\Common\JTest\inc;..\..\Common\JTest\inc\arr_desc;..\..\Common\inc;..\..\Common\inc\templates;..\..\Common\inc\basic_math_tests;..\..\Common\inc\complex_math_tests;..\..\Common\inc\statistics_tests;..\..\Common\inc\matrix_tests;..\..\Common\inc\support_tests;..\..\Common\inc\controller_tests;..\..\Common\inc\transform_tests;..\..\Common\inc\fast_math_tests;..\..\Common\inc\filtering_tests;..\..\Common\inc\intrinsics_tests
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7lfsp (ARM-ADS)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM7 __FPU_PRESENT=1U
  c include: as above
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7lfdp (ARM-ADS)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM7 __FPU_PRESENT=1U
  c include: as above
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MBLl (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MBL
  c misc: -fhonor-nans
  c include: ..\..\..\..\Core\Include;..\..\..\Include;..\..\..\..\..\Device\ARM\ARMv8MBL\Include;..\..\RefLibs\inc;..\..\Common\JTest\inc;..\..\Common\JTest\inc\arr_desc;..\..\Common\inc;..\..\Common\inc\templates;..\..\Common\inc\basic_math_tests;..\..\Common\inc\complex_math_tests;..\..\Common\inc\statistics_tests;..\..\Common\inc\matrix_tests;..\..\Common\inc\support_tests;..\..\Common\inc\controller_tests;..\..\Common\inc\transform_tests;..\..\Common\inc\fast_math_tests;..\..\Common\inc\filtering_tests;..\..\Common\inc\intrinsics_tests
  asm define: ARM_MATH_ARMV8MBL __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MMLl (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML
  c misc: -Xclang -target-feature -Xclang +t2xtpk -fhonor-nans
  c include: ..\..\..\..\Core\Include;..\..\..\Include;..\..\..\..\..\Device\ARM\ARMv8MML\Include;..\..\RefLibs\inc;..\..\Common\JTest\inc;..\..\Common\JTest\inc\arr_desc;..\..\Common\inc;..\..\Common\inc\templates;..\..\Common\inc\basic_math_tests;..\..\Common\inc\complex_math_tests;..\..\Common\inc\statistics_tests;..\..\Common\inc\matrix_tests;..\..\Common\inc\support_tests;..\..\Common\inc\controller_tests;..\..\Common\inc\transform_tests;..\..\Common\inc\fast_math_tests;..\..\Common\inc\filtering_tests;..\..\Common\inc\intrinsics_tests
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLlfsp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML __FPU_PRESENT=1U
  c misc: -Xclang -target-feature -Xclang +t2xtpk -fhonor-nans
  c include: as above
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLlfdpDoNotUse (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DP ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(DFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML __FPU_PRESENT=1U
  c misc: -Xclang -target-feature -Xclang +t2xtpk -fhonor-nans
  c include: as above
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLld (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DSP ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML __DSP_PRESENT=1U
  c misc: -Xclang -target-feature -Xclang +t2xtpk -fhonor-nans
  c include: as above
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLldfsp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DSP_SP ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML __DSP_PRESENT=1U __FPU_PRESENT=1U
  c misc: -Xclang -target-feature -Xclang +t2xtpk -fhonor-nans
  c include: as above
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLldfdpDoNotUse (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DSP_DP ARM
  pack: ARM.CMSIS.5.0.1-dev6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(DFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: DspLibTest_MPS2
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML __DSP_PRESENT=1U __FPU_PRESENT=1U
  c misc: -Xclang -target-feature -Xclang +t2xtpk -fhonor-nans
  c include: as above
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
