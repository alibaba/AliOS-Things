# IAR project NN-example-gru.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM0; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: iar_nnexamples_gru.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Startup
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/Device/ARM/ARMCM0/Include/: ARMCM0.h
    RTE/CMSIS/ARM/: startup_ARMCM0.s system_ARMCM0.c
  group CMSIS-Pack/CMSIS NN Lib
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu_q15.c arm_relu_q7.c
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/NN/Include/: arm_nnfunctions.h
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/NN/Source/PoolingFunctions/: arm_pool_q7_HWC.c
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/Documentation/NN/html/: index.html
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/CMSIS DSP
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/DSP/Include/: arm_math.h
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.5.0-dev0}$/CMSIS/Documentation/DSP/html/: index.html
  group Documentation
    ../: readme_iar.txt
  group Source code
    ./: arm_nnexamples_gru.cpp
