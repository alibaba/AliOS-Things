# Keil uVision project arm_nnexamples_nn_test.uvprojx, settings and files
target ARMCM3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(10000000) ELITTLE
  output: arm_nnexample_nn_test
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM3
  c include: .\Ref_Implementations;..\..\Include;..\nn_test;..\..\..\Core\Include;..\..\..\DSP\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./Ref_Implementations/: arm_convolve_HWC_q7_ref.c arm_convolve_HWC_q7_ref_nonsquare.c arm_convolve_HWC_q15_ref.c arm_depthwise_separable_conv_HWC_q7_ref.c arm_depthwise_separable_conv_HWC_q7_ref_nonsquare.c arm_fully_connected_mat_q7_vec_q15_opt_ref.c arm_fully_connected_mat_q7_vec_q15_ref.c arm_fully_connected_q7_opt_ref.c arm_fully_connected_q7_ref.c arm_fully_connected_q15_opt_ref.c arm_fully_connected_q15_ref.c arm_pool_ref.c arm_relu_ref.c arm_convolve_HWC_q15_ref_nonsquare.c arm_nn_mult_ref.c
    ./: arm_nnexamples_nn_test.cpp
    ../../Source/ActivationFunctions/: arm_nn_activations_q7.c arm_nn_activations_q15.c arm_relu_q7.c arm_relu_q15.c
    ../../Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_basic_nonsquare.c
    ../../Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c
    ../../Source/NNSupportFunctions/: arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_nn_mult_q7.c arm_nn_mult_q15.c
    ../../Source/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_q15.c
    ../../Source/PoolingFunctions/: arm_pool_q7_HWC.c
  group Documentation
    ./: readme.txt
target ARMCM4_FP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_nnexample_nn_test
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM4 __FPU_PRESENT=1U
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1000
target ARMCM7_SP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_nnexamples_nn_test
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM7 __FPU_PRESENT=1U
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM4b_FP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: as above
  output: arm_nnexample_nn_test
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM4 __FPU_PRESENT=1U ARM_MATH_BIG_ENDIAN
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1000
target ARMCM7b_SP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: as above
  output: arm_nnexamples_nn_test
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM7 __FPU_PRESENT=1U ARM_MATH_BIG_ENDIAN
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM4_FP_truncate (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: as above
  output: arm_nnexample_nn_test
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM4 __FPU_PRESENT=1U ARM_NN_TRUNCATE
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1, Compiler:I/O:STDERR 1.2.1, Compiler:I/O:STDOUT 1.2.1, Compiler:I/O:TTY 1.2.1
