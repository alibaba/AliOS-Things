# IAR project mini_bl.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1052DVL6B
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\..\platform\mcu\mimxrt1052\CMSIS\Include; ..\..\..\..\platform\mcu\mimxrt1052; ..\..\..\..\platform\mcu\mimxrt1052\boot; ..\..\..\..\platform\mcu\mimxrt1052\drivers; ..\..\..\..\platform\mcu\mimxrt1052\component\mini_bl; ..\..\..\..\board\evkbimxrt1050\boot; ..\..\..\..\board\evkbimxrt1050; ..\..\..\..\include; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\utility\digest_algorithm
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: mini_bl.bin
  ILINK.IlinkOutputFile: mini_bl.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1052DVL6B
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../../../../board/evkbimxrt1050/: board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../platform/mcu/mimxrt1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h
  group source
    ../../../../utility/digest_algorithm/: crc.c
    ../../../../platform/mcu/mimxrt1052/component/mini_bl/: fsl_mini_bl.c fsl_mini_bl.h main.c
  group startup
    ../../../../platform/mcu/mimxrt1052/iar/: startup_MIMXRT1052.s
    ../../../../platform/mcu/mimxrt1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group boot
    ../../../../board/evkbimxrt1050/boot/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_mini_bl.c evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
    ../../../../platform/mcu/mimxrt1052/boot/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
