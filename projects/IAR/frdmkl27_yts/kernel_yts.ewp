# IAR project kernel_yts.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL27Z64xxx4 NXP MKL27Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL27Z64VLH4; DEBUG; FRDM_KL27Z; FREEDOM; _TIMESPEC_DEFINED; _DLIB_FILE_DESCRIPTOR=1; AOS_LOOP; AOS_KV; AOS_HAL; HAVE_NOT_ADVANCED_FORMATE; VCALL_RHINO; CONFIG_NO_TCPIP; SYSINFO_OS_VERSION="AOS-R-1.3.1-"; SYSINFO_PRODUCT_MODEL="ALI_AOS_FRDMKL27Z"; SYSINFO_DEVICE_NAME="FRDMKL27Z"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.1"; SYSINFO_APP_VERSION="APP-1.0.0-20171128.1211"; SYSINFO_ARCH="Cortex-M0"; SYSINFO_MCU="mkl27z644"; TEST_CONFIG_KV_ENABLED=0; TEST_CONFIG_YLOOP_ENABLED=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\include; ..\..\..\kernel\rhino\core\include; ..\..\..\platform\mcu\mkl27z644; ..\..\..\test\yunit\include; ..\..\..\kernel\vcall\aos; ..\..\..\kernel\modules\fs\kv\include; ..\..\..\platform\mcu\mkl27z644\drivers; ..\..\..\platform\mcu\mkl27z644\CMSIS\Include; ..\..\..\board\frdmkl27z; ..\..\..\platform\arch\arm\armv6m\iccarm\m0; ..\..\..\kernel\vfs\include; ..\..\..\test\testcase\include; ..\..\..\utility\libc\compilers\EWARM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: kernel_yts.srec
  ILINK.IlinkOutputFile: kernel_test.out
  ILINK.IlinkIcfFile: ..\..\..\platform\mcu\mkl27z644\iar\MKL27Z64xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; CPU_MKL27Z64VLH4; FRDM_KL27Z; FREEDOM; _TIMESPEC_DEFINED; AOS_LOOP; AOS_KV; AOS_HAL; HAVE_NOT_ADVANCED_FORMATE; VCALL_RHINO; CONFIG_NO_TCPIP; SYSINFO_OS_VERSION="AOS-R-1.3.1-"; SYSINFO_PRODUCT_MODEL="ALI_AOS_B-L475E"; SYSINFO_DEVICE_NAME="B-L475E"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.1"; SYSINFO_APP_VERSION="APP-1.0.0-20171128.1211"; SYSINFO_ARCH="Cortex-M0"; SYSINFO_MCU="mkl27z644"; TEST_CONFIG_KV_ENABLED=0; TEST_CONFIG_YLOOP_ENABLED=1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: kernel_yts.hex
  ILINK.IlinkOutputFile: kernel_yts.out
  group auto
    auto/: component_init.c testcase_register.c
  group board
    ../../../board/frdmkl27z/: board.c board.h clock_config.c clock_config.h k_config.h pin_mux.c pin_mux.h
  group example
    ../../../example/yts/: main.c
  group include/aos
    ../../../include/aos/: alink.h aos.h cli.h cloud.h debug.h errno.h init.h kernel.h kv.h list.h log.h mbedtls_ssl.h network.h types.h uData.h version.h vfs.h yloop.h
  group kernel/modules/fs/kv
    ../../../kernel/modules/fs/kv/: kvmgr.c
  group kernel/modules/fs/kv/include
    ../../../kernel/modules/fs/kv/include/: kvmgr.h
  group kernel/rhino
    ../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_obj_set.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group kernel/rhino/include
    ../../../kernel/rhino/core/include/: k_api.h k_bitmap.h k_buf_queue.h k_critical.h k_default_config.h k_endian.h k_err.h k_event.h k_fifo.h k_hook.h k_internal.h k_list.h k_mm.h k_mm_blk.h k_mm_debug.h k_mm_region.h k_mutex.h k_obj.h k_obj_set.h k_queue.h k_ringbuf.h k_sched.h k_sem.h k_soc.h k_stats.h k_sys.h k_task.h k_task_sem.h k_time.h k_timer.h k_trace.h k_workqueue.h
  group kernel/vcall
    ../../../kernel/vcall/aos/: aos_rhino.c
  group kernel/vfs
    ../../../kernel/vfs/: device.c vfs.c vfs_inode.c vfs_register.c
  group kernel/vfs/device
    ../../../kernel/vfs/device/: vfs_adc.c vfs_gpio.c vfs_i2c.c vfs_pwm.c vfs_rtc.c vfs_spi.c vfs_uart.c vfs_wdg.c
  group kernel/vfs/include
    ../../../kernel/vfs/include/: event_device.h vfs.h vfs_conf.h vfs_err.h vfs_inode.h vfs_register.h
  group kernel/vfs/include/device
    ../../../kernel/vfs/include/device/: vfs_adc.h vfs_device.h vfs_gpio.h vfs_i2c.h vfs_pwm.h vfs_rtc.h vfs_spi.h vfs_uart.h vfs_wdg.h
  group kernel/yloop
    ../../../kernel/yloop/: local_event.c yloop.c yloop.h
  group platform/arch/arm/armv6m
    ../../../platform/arch/arm/armv6m/iccarm/m0/: k_types.h port.h port_c.c port_s.S
  group platform/mcu
    ../../../platform/mcu/mkl27z644/: fsl_device_registers.h MKL27Z644.h MKL27Z644_features.h system_MKL27Z644.c system_MKL27Z644.h
    ../../../platform/mcu/mkl27z644/iar/: startup_MKL27Z644.s
  group platform/mcu/aos
    ../../../platform/mcu/mkl27z644/aos/: aos.c soc_impl.c
  group platform/mcu/CMSIS
    ../../../platform/mcu/mkl27z644/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_cm0plus.h
  group platform/mcu/drivers
    ../../../platform/mcu/mkl27z644/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group platform/mcu/hal
    ../../../platform/mcu/mkl27z644/hal/: hal_flash.c hal_uart.c
  group test/testcase
    ../../../test/testcase/: yts_main.c
  group test/testcase/certificate
    ../../../test/testcase/certificate_test/: aos_test.c
  group test/testcase/certificate/cutest
    ../../../test/testcase/certificate_test/cutest/: cut.c cut.h
  group test/yunit
    ../../../test/yunit/: yunit.c
  group test/yunit/include
    ../../../test/yunit/include/: yunit.h
  group utility/libc/EWARM
    ../../../utility/libc/compilers/EWARM/: iar_libc.c
  group utility/libc/EWARM/sys
    ../../../utility/libc/compilers/EWARM/sys/: errno.h fcntl.h reent.h select.h stat.h time.h types.h unistd.h
  group utility/log
    ../../../utility/log/: log.c
