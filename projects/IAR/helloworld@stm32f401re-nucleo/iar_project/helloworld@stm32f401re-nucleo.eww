<?xml version="1.0" encoding="UTF-8"?>

<workspace>
  <project>
    <path>$WS_DIR$\helloworld@stm32f401re-nucleo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


