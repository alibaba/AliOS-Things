<?xml version="1.0" encoding="UTF-8"?>

<workspace>
  <project>
    <path>$WS_DIR$\sensorapp@b_l475e.ewp</path>
  </project>
  <batchBuild/>
</workspace>


