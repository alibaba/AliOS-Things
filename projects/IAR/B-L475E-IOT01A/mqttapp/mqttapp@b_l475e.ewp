# IAR project mqttapp@b_l475e.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mqttapp@b_l475e.out
  ILINK.IlinkIcfFile: ../../../../platform/mcu/stm32l475/STM32L475.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group alicrypto
    ../../../../security/alicrypto/libalicrypto/: ali_crypto.c
    ../../../../security/alicrypto/libalicrypto/sw/: ali_crypto_rand.c
    ../../../../security/alicrypto/libalicrypto/test/: ali_crypto_test.c ali_crypto_test_comm.c ali_crypto_test_hash.c ali_crypto_test_hmac.c ali_crypto_test_rand.c ali_crypto_test_rsa.c
    ../../../../security/alicrypto/mbedtls/library/: asn1parse.c hash_wrap.c sha1.c sha256.c threading.c
    ../../../../security/alicrypto/libalicrypto/mbed/hash/: hash.c
    ../../../../security/alicrypto/libalicrypto/mbed/mac/: hmac.c
    ./: security_alicrypto_libalicrypto_mbed_asym_rsa.c security_alicrypto_libalicrypto_mbed_cipher_aes.c security_alicrypto_mbedtls_library_aes.c security_alicrypto_mbedtls_library_bignum.c security_alicrypto_mbedtls_library_hmac.c security_alicrypto_mbedtls_library_mbedtls_alt.c security_alicrypto_mbedtls_library_md5.c security_alicrypto_mbedtls_library_oid.c security_alicrypto_mbedtls_library_rsa.c
  group armv7m
    ../../../../platform/arch/arm/armv7m/iccarm/m4/: port_c.c port_s.S
  group atparser
    ../../../../framework/atparser/: atparser.c
  group base64
    ./: utility_base64_base64.c
  group board_b_l475e
    ../../../../board/b_l475e/: board.c osa_flash.c
  group chip_code
    ../../../../utility/chip_code/: chip_code.c
  group cjson
    ../../../../utility/cjson/: cJSON.c cJSON_Utils.c
  group cli
    ../../../../tools/cli/: cli.c dumpsys.c
  group cloud
    ../../../../framework/cloud/: cloud.c
  group device_sal_mk3060
    ../../../../device/sal/wifi/mk3060/: mk3060.c wifi_atcmd.c
  group digest_algorithm
    ../../../../utility/digest_algorithm/: CheckSumUtils.c crc.c digest_algorithm.c md5.c
  group download_http
    ../../../../framework/fota/download/http/: ota_download.c
  group external_lib
    ../../../../framework/activation/Cortex-M4/IAR/: activation.a
  group fota
    ../../../../framework/fota/: ota_service.c ota_update_manifest.c ota_util.c ota_version.c
  group fota_download
    ../../../../framework/fota/download/: download_common.c
  group fota_mqtt_transport
    ../../../../framework/fota/platform/mqtt/: ota_transport.c version_report.c
  group fota_platform
    ../../../../framework/fota/platform/: ota_platform_os.c
  group framework
    ./: framework_common_version.c
    ../../../../framework/common/: main.c
  group hal
    ./: kernel_hal_wifi.c
    ../../../../kernel/hal/: ota.c
  group hashtable
    ../../../../utility/hashtable/: hashtable.c
  group iotkit
    ../../../../framework/protocol/linkkit/iotkit/iotkit-system/src/: ca.c class_interface.c guider.c id2_guider.c report.c sdk-impl.c
    ../../../../framework/protocol/linkkit/iotkit/layers/config/src/: dev_conf.c
    ./: framework_protocol_linkkit_iotkit_iotkit-system_src_device.c
    ../../../../framework/protocol/linkkit/iotkit/hal-impl/tls/mbedtls/: HAL_DTLS_mbedtls.c HAL_TLS_mbedtls.c
    ../../../../framework/protocol/linkkit/iotkit/hal-impl/rhino/: HAL_OS_rhino.c HAL_PRODUCT_rhino.c HAL_TCP_rhino.c HAL_UDP_rhino.c
    ../../../../framework/protocol/linkkit/iotkit/base/utils/LITE-utils/src/: json_parser.c json_token.c mem_stats.c string_utils.c
    ../../../../framework/protocol/linkkit/iotkit/base/log/LITE-log/: lite-log.c
    ../../../../framework/protocol/linkkit/iotkit/base/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
    ../../../../framework/protocol/linkkit/iotkit/base/utils/misc/: utils_epoch_time.c utils_httpc.c utils_list.c utils_net.c utils_timer.c work_queue.c
  group kernel_init
    ../../../../kernel/init/: aos_init.c
  group kv
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group log
    ../../../../utility/log/: log.c
  group mbedtls
    ../../../../security/mbedtls/src/: aes.c aesni.c arc4.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c mbedtls_alt.c mbedtls_net.c mbedtls_ssl.c md.c md2.c md4.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mqtt
    ../../../../framework/connectivity/mqtt/: mqtt_client.c mqtt_instance.c
  group mqttapp
    ../../../../example/mqttapp/: mqtt-example.c
  group MQTTPacket
    ../../../../framework/connectivity/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group netmgr
    ../../../../framework/netmgr/: netmgr.c
  group newlib_stub
    ../../../../utility/libc/compilers/iar/: iar_libc.c
  group rhino
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
    ../../../../kernel/rhino/common/: k_fifo.c k_trace.c
    ../../../../kernel/rhino/debug/: k_overview.c
  group sal
    ../../../../device/sal/: ip4_addr.c sal.c sal_arch.c sal_device.c sal_err.c sal_sockets.c
  group socket_stand
    ../../../../framework/fota/download/http/socket/stand/: ota_socket.c
  group stm32l475
    ../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/runapp/: aos.c soc_init.c startup_stm32l475xx_icc.s stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/es_wifi/: es_wifi.c
    ../../../../platform/mcu/stm32l475/src/common/csp/wifi/src/: es_wifi_io.c wifi.c
    ../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/hal/: flash_l4.c flash_port.c hal_i2c_stm32l4.c hw.c ota_port.c wifi_port.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/hts221/: hts221.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lps22hb/: lps22hb.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
    ../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/sensor/: qspi.c sensors.c sensors_data.c vl53l0x_platform.c vl53l0x_proximity.c
    ../../../../platform/mcu/stm32l475/aos/: soc_impl.c trace_impl.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_tsensor.c
    ../../../../platform/mcu/stm32l475/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
    ../../../../platform/mcu/stm32l475/Middlewares/USB_Device/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group vcall
    ../../../../kernel/vcall/aos/: aos_rhino.c
  group vfs
    ../../../../kernel/vfs/: device.c select.c vfs.c vfs_file.c vfs_inode.c vfs_register.c
  group vfs_device
    ../../../../kernel/vfs/device/: vfs_adc.c vfs_gpio.c vfs_i2c.c vfs_pwm.c vfs_rtc.c vfs_spi.c vfs_uart.c vfs_wdg.c
  group yloop
    ../../../../kernel/yloop/: local_event.c yloop.c
