<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ATSAME54XPRO.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\temp\EDBG UART\SAME54_EDBG.ewp</path>
    </project>
    <batchBuild />
</workspace>
