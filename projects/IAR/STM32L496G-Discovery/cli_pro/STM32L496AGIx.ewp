# IAR project STM32L496AGIx.ewp, settings and files
configuration STM32L496AGIx (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496AG ST STM32L496AG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L496xx; SYSINFO_OS_VERSION="APP-1.0.0"; SYSINFO_PRODUCT_MODEL="ALI_AOS_STM32L496AGIx"; SYSINFO_DEVICE_NAME="STM32L496AGIx"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.0"; SYSINFO_APP_VERSION="APP-1.0.0"; STDIO_UART=0; CONFIG_NO_TCPIP; __BSD_VISIBLE; RHINO_CONFIG_TICK_TASK=0; _TIMESPEC_DEFINED; CONFIG_AOS_CLI; VCALL_RHINO
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\kernel\rhino\core\include; ..\..\..\..\platform\arch\arm\armv7m\iccarm\m4; ..\..\..\..\platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\platform\mcu\stm32l4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\platform\mcu\stm32l4xx\Drivers\CMSIS\Include; ..\..\..\..\platform\mcu\stm32l4xx\src\STM32L496G-Discovery\cli_pro; ..\..\..\..\include\hal; ..\..\..\..\kernel\vcall\aos; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\tools\cli; ..\..\..\..\platform\mcu\stm32l4xx\src\STM32L496G-Discovery\hal; ..\..\..\..\kernel\vfs\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32L496AGIx.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group AOS/Arch
    ../../../../platform/arch/arm/armv7m/iccarm/m4/: port_c.c port_s.S
  group AOS/Cli
    ../../../../tools/cli/: dumpsys.c cli.c
  group AOS/Kernel
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group AOS/Libc
    ../../../../utility/libc/compilers/iar/: iar_libc.c
  group AOS/Utility
    ../../../../utility/log/: log.c
  group AOS/vfs
    ../../../../kernel/vfs/: vfs.c
    ../../../../kernel/vcall/aos/: aos_rhino.c
  group Application
    ../../../../platform/mcu/stm32l4xx/aos/: soc_impl.c
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/cli_pro/: soc_init.c stm32l4xx_exc.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/hal
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/hal/: hal_uart_stm32l4.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/mcu/stm32l4xx/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/SYSTEM
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/: startup_stm32l496xx_iar.s
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/cli_pro/: system_stm32l4xx.c
  group Example
    ../../../../example/rhinorun/: rhinorun.c
