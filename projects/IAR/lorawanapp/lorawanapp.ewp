# IAR project lorawanapp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071KB ST STM32L071KB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L071xx; USE_FULL_LL_DRIVER; USE_B_EML3047; USE_HAL_DRIVER; REGION_CN470; SYSINFO_OS_VERSION="AOS-R-1.2.2-"; SYSINFO_PRODUCT_MODEL="ALI_AOS_B-L475E"; SYSINFO_DEVICE_NAME="B-L475E"; SYSINFO_KERNEL_VERSION="AOS-R-1.2.2"; SYSINFO_APP_VERSION="APP-1.0.0-20171128.1211"; STDIO_UART=0; CONFIG_NO_TCPIP; __BSD_VISIBLE; RHINO_CONFIG_TICK_TASK=0
  ICCARM.CCIncludePath2: ..\..\..\board\eml3047; ..\..\..\board\eml3047\inc; ..\..\..\device\lora\sx1276; ..\..\..\device\lora\eml3047_lrwan; ..\..\..\example\lorawanapp; ..\..\..\kernel\protocols\lorawan\Lora\Crypto; ..\..\..\kernel\protocols\lorawan\Lora\Phy; ..\..\..\kernel\protocols\lorawan\Lora\Mac; ..\..\..\kernel\protocols\lorawan\Lora\Mac\region; ..\..\..\kernel\protocols\lorawan\Lora\Core; ..\..\..\kernel\protocols\lorawan\Lora\Utilities; ..\..\..\kernel\protocols\lorawan\Lora\hal; ..\..\..\kernel\rhino\core\include; ..\..\..\platform\arch\arm\armv6m\iccarm\m0; ..\..\..\platform\mcu\stm32l0xx\src\STM32L071KB\runapp; ..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Include; ..\..\..\platform\mcu\stm32l0xx\src\STM32L071KB\runapp; ..\..\..\include; ..\..\..\utility\libc\compilers\iar
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lorawanapp.out
  ILINK.IlinkIcfFile: ..\..\..\platform\mcu\stm32l0xx\stm32l071kb\stm32l071xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group board/eml3047
    ../../../board/eml3047/: board.c
    ../../../board/eml3047/src/: debug.c eml3047_hw.c eml3047_it.c hw_gpio.c hw_rtc.c hw_spi.c lora.c vcom.c
  group device/eml3047_lrwan
    ../../../device/lora/eml3047_lrwan/: eml3047.c
  group device/sx127x
    ../../../device/lora/sx1276/: sx1276.c
  group example
    ../../../example/lorawanapp/: lorawanapp.c
  group example/src
    ../../../platform/mcu/stm32l0xx/src/STM32L071KB/runapp/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
    ../../../platform/mcu/stm32l0xx/aos/: soc_impl.c
  group kernel/protocols/lora/crypto
    ../../../kernel/protocols/lorawan/Lora/Crypto/: aes.c cmac.c
  group kernel/protocols/lora/hal
    ../../../kernel/protocols/lorawan/Lora/hal/: lorawan_port.c
  group kernel/protocols/lora/mac
    ../../../kernel/protocols/lorawan/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
  group kernel/protocols/lora/mac/region
    ../../../kernel/protocols/lorawan/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group kernel/protocols/lora/utilities
    ../../../kernel/protocols/lorawan/Lora/Utilities/: delay.c low_power.c timeServer.c utilities.c
  group kernel/rhino
    ../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group kernel/vcall
    ../../../kernel/vcall/aos/: aos_rhino.c
  group platform/arch
    ../../../platform/arch/arm/armv6m/iccarm/m0/: port_c.c port_s.S
  group platform/mcu/drivers/cmsis
    ../../../platform/mcu/stm32l0xx/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l071xx.s
    ../../../platform/mcu/stm32l0xx/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group platform/mcu/drivers/hal
    ../../../platform/mcu/stm32l0xx/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_ll_gpio.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_usart.c
