# IAR project mini_bl.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1021DAG5A
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\..\platform\mcu\mimxrt1021\CMSIS\Include; ..\..\..\..\platform\mcu\mimxrt1021; ..\..\..\..\platform\mcu\mimxrt1021\boot; ..\..\..\..\platform\mcu\mimxrt1021\drivers; ..\..\..\..\platform\mcu\mimxrt1021\component\mini_bl; ..\..\..\..\board\evkmimxrt1020\boot; ..\..\..\..\board\evkmimxrt1020; ..\..\..\..\include; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\utility\digest_algorithm
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: mini_bl.bin
  ILINK.IlinkOutputFile: mini_bl.out
  ILINK.IlinkIcfFile: MIMXRT1021xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1021DAG5A
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../../../../board/evkmimxrt1020/: board.c board.h clock_config.c clock_config.h
  group boot
    ../../../../board/evkmimxrt1020/boot/: evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_flexspi_nor_config.h evkmimxrt1020_mini_bl.c evkmimxrt1020_sdram_ini_dcd.c evkmimxrt1020_sdram_ini_dcd.h
    ../../../../platform/mcu/mimxrt1021/boot/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../../../platform/mcu/mimxrt1021/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h
  group source
    ../../../../utility/digest_algorithm/: crc.c
    ../../../../platform/mcu/mimxrt1021/component/mini_bl/: fsl_mini_bl.c fsl_mini_bl.h main.c
  group startup
    ../../../../platform/mcu/mimxrt1021/iar/: startup_MIMXRT1021.s
    ../../../../platform/mcu/mimxrt1021/: system_MIMXRT1021.c system_MIMXRT1021.h
