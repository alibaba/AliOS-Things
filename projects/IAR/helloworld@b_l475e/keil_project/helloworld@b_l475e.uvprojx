# Keil uVision project helloworld@b_l475e.uvprojx, settings and files
target helloworld@b_l475e (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: helloworld@b_l475e
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: ..\..\..\..\platform\mcu\stm32l475\B-L475E-IOT01.sct
  group helloworld
    ../../../.././app/example/helloworld/: helloworld.c
  group board_b_l475e
    ../../../.././board/b_l475e/: board.c osa_flash.c
  group stm32l475
    ../../../../././platform/mcu/stm32l475/Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_tsensor.c
    ../../../../././platform/mcu/stm32l475/Drivers/BSP/Components/es_wifi/: es_wifi.c
    ../../../../././platform/mcu/stm32l475/Drivers/BSP/Components/hts221/: hts221.c
    ../../../../././platform/mcu/stm32l475/Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../../../../././platform/mcu/stm32l475/Drivers/BSP/Components/lps22hb/: lps22hb.c
    ../../../../././platform/mcu/stm32l475/Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
    ../../../../././platform/mcu/stm32l475/Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
    ../../../../././platform/mcu/stm32l475/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
    ../../../../././platform/mcu/stm32l475/aos/: soc_impl.c trace_impl.c
    ../../../../././platform/mcu/stm32l475/src/B-L475E-IOT01/hal/: flash_l4.c flash_port.c hal_i2c_stm32l4.c hw.c wifi_port.c
    ../../../../././platform/mcu/stm32l475/src/B-L475E-IOT01/runapp/: aos.c soc_init.c startup_stm32l475xx_armcc.s stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
    ../../../../././platform/mcu/stm32l475/src/B-L475E-IOT01/sensor/: sensors.c sensors_data.c vl53l0x_platform.c vl53l0x_proximity.c
    ../../../../././platform/mcu/stm32l475/src/common/csp/wifi/src/: es_wifi_io.c wifi.c
  group osal
    ../../../../././osal/aos/: aos_common.c aos_kv.c aos_rhino.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group yloop
    ../../../.././network/yloop/: device.c local_event.c select.c yloop.c
  group cli
    ../../../.././tools/cli/: cli.c dumpsys.c
  group sal
    ../../../.././middleware/linkkit/sdk-c/src/services/mdal/sal/./src/: ip4_addr.c sal_arch_aos.c sal_err.c sal_sockets.c
  group armv7m
    ../../../../././platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.S
    ../../../../././platform/arch/arm/armv7m/panic/: panic_armcc.S panic_c.c
  group newlib_stub
    ../../../.././utility/libc/compilers/armlibc/: armcc_libc.c hal_stub.c
  group rhino
    ../../../.././kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_spin_lock.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group hal
    ../../../.././kernel/hal/: hal.c
  group halwifi
    ../../../.././network/halwifi/: wifi.c
  group kv
    ../../../../././kernel/fs/kv/: kv.c kv_adapt.c kv_cli.c
  group vfs
    ../../../../././kernel/fs/vfs/: vfs.c vfs_file.c vfs_inode.c vfs_register.c
  group digest_algorithm
    ../../../.././utility/digest_algorithm/: CheckSumUtils.c crc.c crc16.c digest_algorithm.c md5.c
  group common
    ../../../../././middleware/common/: main.c version.c
  group log
    ../../../.././utility/log/: log.c
  group device_sal_mk3060
    ../../../.././network/sal/wifi/mk3060/: mk3060.c wifi_atcmd.c
  group vfs_device
    ../../../../././kernel/fs/vfs/device/: vfs_adc.c vfs_gpio.c vfs_i2c.c vfs_pwm.c vfs_rtc.c vfs_spi.c vfs_uart.c vfs_wdg.c
  group atparser
    ../../../../././network/sal/atparser/: atparser.c
