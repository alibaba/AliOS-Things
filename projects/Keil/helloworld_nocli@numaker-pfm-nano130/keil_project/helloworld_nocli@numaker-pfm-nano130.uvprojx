# Keil uVision project helloworld_nocli@numaker-pfm-nano130.uvprojx, settings and files
target helloworld_nocli@numaker-pfm-nano130 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: helloworld_nocli@numaker-pfm-nano130
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\platform\mcu\nano130ke3bn\NANO130.sct
  group helloworld_nocli
    ../../../.././app/example/helloworld_nocli/: helloworld_nocli.c
  group numaker-pfm-nano130
    ../../../.././board/numaker-pfm-nano130/aos/: board.c board_cli.c soc_init.c
    ../../../.././board/numaker-pfm-nano130/: startup_Nano100Series.c
  group nano130ke3bn
    ../../../../././platform/mcu/nano130ke3bn/Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../../../././platform/mcu/nano130ke3bn/Library/StdDriver/src/: adc.c clk.c dac.c fmc.c gpio.c i2c.c pdma.c pwm.c retarget.c rtc.c spi.c sys.c timer.c uart.c wdt.c
    ../../../../././platform/mcu/nano130ke3bn/aos/: aos.c soc_impl.c trace_impl.c
    ../../../../././platform/mcu/nano130ke3bn/hal/common/: PeripheralPins.c pinmap.c pinmap_common.c
    ../../../../././platform/mcu/nano130ke3bn/hal/: hal_dummy.c hal_flash.c hal_timer.c hal_uart.c hw.c
    ../../../../././platform/mcu/nano130ke3bn/hal/misc/: nu_modutil.c
  group osal
    ../../../../././osal/aos/: aos_rhino.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group yloop
    ../../../.././kernel/yloop/: device.c local_event.c select.c yloop.c
  group armv6m
    ../../../../././platform/arch/arm/armv6m/armcc/m0/: port_c.c port_s.S
    ../../../../././platform/arch/arm/armv6m/panic/: panic_armcc.S panic_c.c
  group rhino
    ../../../.././kernel/rhino/common/: k_fifo.c k_trace.c
    ../../../.././kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
    ../../../.././kernel/rhino/debug/: k_backtrace.c k_infoget.c k_overview.c k_panic.c
    ../../../.././kernel/rhino/uspace/: u_task.c
  group newlib_stub
    ../../../.././utility/libc/compilers/armlibc/: armcc_libc.c hal_stub.c
  group common
    ../../../../././middleware/common/: main.c version.c
  group cloud
    ../../../../././middleware/alink/cloud/: cloud.c
  group log
    ../../../.././utility/log/: log.c
  group vfs
    ../../../.././kernel/rhino/vfs/: vfs.c vfs_file.c vfs_inode.c vfs_register.c
  group kv
    ../../../.././kernel/rhino/fs/kv/: kv_osal.c kvmgr.c
  group vfs_device
    ../../../../././kernel/rhino/vfs/device/: vfs_adc.c vfs_gpio.c vfs_i2c.c vfs_pwm.c vfs_rtc.c vfs_spi.c vfs_uart.c vfs_wdg.c
