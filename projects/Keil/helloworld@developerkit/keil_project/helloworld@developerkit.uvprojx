# Keil uVision project helloworld@developerkit.uvprojx, settings and files
target helloworld@developerkit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L496VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: helloworld@developerkit
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\platform\mcu\stm32l475\B-L475E-IOT01.sct
  group helloworld
    ../../../.././app/example/helloworld/: helloworld.c
  group developerkit
    ../../../.././board/developerkit/: += developerkit_SOURCES startup_stm32l496xx_keil.s
    ../../../.././board/developerkit/Src/: adc.c crc.c dcmi.c dma.c gpio.c i2c.c irtim.c main.c sai.c sdmmc.c spi.c stm32l4xx_hal_msp.c tim.c usart.c usb_otg.c
    ../../../.././board/developerkit/aos/: board.c board_cli.c soc_init.c st7789.c
    ../../../.././board/developerkit/mbmaster_hal/: port_serial.c
    ../../../.././board/developerkit/pwrmgmt_hal/: board_cpu_pwr.c board_cpu_pwr_rtc.c board_cpu_pwr_systick.c board_cpu_pwr_timer.c
  group stm32l4xx_cube
    ../../../../././platform/mcu/stm32l4xx_cube/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../../../././platform/mcu/stm32l4xx_cube/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
    ../../../../././platform/mcu/stm32l4xx_cube/aos/: aos.c hook_impl.c rttest_impl.c soc_impl.c trace_impl.c
    ../../../../././platform/mcu/stm32l4xx_cube/hal/: hal_adc_stm32l4.c hal_flash_stm32l4.c hal_gpio_stm32l4.c hal_i2c_stm32l4.c hal_nand_stm32l4.c hal_nor_stm32l4.c hal_qspi_stm32l4.c hal_rtc_stm32l4.c hal_sd_stm32l4.c hal_spi_stm32l4.c hal_uart_stm32l4.c hw.c
  group osal
    ../../../../././osal/aos/: aos_common.c aos_rhino.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group yloop
    ../../../.././network/yloop/: device.c local_event.c select.c yloop.c
  group cli
    ../../../.././tools/cli/: cli.c dumpsys.c
  group sensor
    ../../../.././device/sensor/drv/: drv_acc_bosch_bma253.c drv_acc_gyro_st_lsm6dsl.c drv_acc_mir3_da217.c drv_als_ps_liteon_ltr553.c drv_baro_bosch_bmp280.c drv_baro_st_lps22hb.c drv_humi_bosch_bme280.c drv_mag_st_lis3mdl.c drv_mag_temp_memsic_mmc3680kj.c drv_temp_humi_sensirion_shtc1.c drv_temp_humi_st_hts221.c
    ../../../.././device/sensor/hal/: sensor_drv_api.c sensor_hal.c
  group sal
    ../../../.././middleware/linkkit/sdk-c/src/services/mdal/sal/./src/: ip4_addr.c sal_arch_aos.c sal_err.c sal_sockets.c
  group armv7m
    ../../../../././platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.S
    ../../../../././platform/arch/arm/armv7m/panic/: panic_armcc.S panic_c.c
  group newlib_stub
    ../../../.././utility/libc/compilers/armlibc/: armcc_libc.c hal_stub.c
  group rhino
    ../../../.././kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_spin_lock.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
    ../../../.././kernel/rhino/debug/cpuusage/: k_cpuusage.c
    ../../../.././kernel/rhino/debug/: k_backtrace.c k_infoget.c k_overview.c k_panic.c
    ../../../.././kernel/rhino/debug/trace/: k_fifo.c k_trace.c
  group hal
    ../../../.././kernel/hal/: hal.c
  group halwifi
    ../../../.././network/halwifi/: wifi.c
  group vfs
    ../../../.././kernel/rhino/vfs/: vfs.c vfs_file.c vfs_inode.c vfs_register.c
  group digest_algorithm
    ../../../.././utility/digest_algorithm/: CheckSumUtils.c crc.c crc16.c digest_algorithm.c md5.c
  group kv
    ../../../../././kernel/rhino/fs/kv/: kv_osal.c kvmgr.c
  group common
    ../../../../././middleware/common/: main.c version.c
  group log
    ../../../.././utility/log/: log.c
  group device_sal_bk7231
    ../../../.././network/sal/wifi/bk7231/: bk7231.c wifi_atcmd_bk7231.c
  group vfs_device
    ../../../../././kernel/rhino/vfs/device/: vfs_adc.c vfs_gpio.c vfs_i2c.c vfs_pwm.c vfs_rtc.c vfs_spi.c vfs_uart.c vfs_wdg.c
  group atparser
    ../../../../././network/sal/atparser/: atparser.c
