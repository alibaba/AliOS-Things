# Keil uVision project ES8P508x.uvproj, settings and files
target ES8P508x (ARM-ADS)
  device: ES8P508FLXX ES
  cpu: IRAM(0x20000000-0x20005FFF)  IROM(0x00000000-0x0001FFFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: ES8P508x
  c flags: Optim=1 OneElfS=1
  c define: __PRINTF_USE_UART2__,AOS_KV
  c misc: --bitband --C99 -DCONFIG_NO_TCPIP
  c include: ..\..\..\..\kernel\rhino\core\include;..\..\..\..\platform\arch\arm\armv6m\armcc\m0plus;..\..\..\..\platform\mcu\es8p508x\library\Include;..\..\..\..\platform\mcu\es8p508x\cmsis;..\..\..\..\platform\mcu\es8p508x\hrsdk;..\..\..\..\platform\mcu\es8p508x\HRSDK_GDB_ES8P508x\helloworld;..\..\..\..\include;..\..\..\..\include\hal;..\..\..\..\kernel\vcall\aos;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\include\aos;..\..\..\..\test\yunit\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group platform\mcu\es8p508x\library\Source
    ../../../../platform/mcu/es8p508x/library/Source/: lib_adc.c lib_aes.c lib_crc.c lib_flashiap.c lib_gpio.c lib_iap.c lib_iic.c lib_printf.c lib_rtc.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group platform\mcu\es8p508x\HRSDK_GDB_ES8P508x
    ../../../../platform/mcu/es8p508x/HRSDK_GDB_ES8P508x/: startup_ES8P508x.s
    ../../../../platform/mcu/es8p508x/HRSDK_GDB_ES8P508x/helloworld/: system_ES8P508x.c sdk_init.c irqhandler.c
  group kernel\rhino\core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_obj_set.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
    ../../../../kernel/rhino/common/: k_fifo.c k_trace.c
  group platform\mcu\es8p508x\aos
    ../../../../platform/mcu/es8p508x/aos/: soc_impl.c
  group platform\arch\arm\armv6m\armcc\m0plus
    ../../../../platform/arch/arm/armv6m/armcc/m0plus/: port_c.c port_s.s
  group example\esapp\helloworld
    ../../../../platform/mcu/es8p508x/HRSDK_GDB_ES8P508x/helloworld/: hook_impl.c
    ../../../../example/esapp/: helloworld.c
