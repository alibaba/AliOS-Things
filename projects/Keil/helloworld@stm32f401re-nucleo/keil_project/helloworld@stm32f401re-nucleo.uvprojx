# Keil uVision project helloworld@stm32f401re-nucleo.uvprojx, settings and files
target helloworld@stm32f401re-nucleo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: helloworld@stm32f401re-nucleo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: ..\..\..\..\platform\mcu\stm32l475\B-L475E-IOT01.sct
  group helloworld
    ../../../.././app/example/helloworld/: helloworld.c
  group stm32f401re-nucleo
    ../../../.././board/stm32f401re-nucleo/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../../../.././board/stm32f401re-nucleo/aos/: board.c soc_init.c
    ../../../.././board/stm32f401re-nucleo/: startup_stm32f401xe_keil.s
  group stm32f4xx_cube
    ../../../../././platform/mcu/stm32f4xx_cube/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../../././platform/mcu/stm32f4xx_cube/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
    ../../../../././platform/mcu/stm32f4xx_cube/aos/: aos.c soc_impl.c
    ../../../../././platform/mcu/stm32f4xx_cube/hal/: hal_flash_stm32f4.c hal_gpio_stm32f4.c hal_i2c_stm32f4.c hal_spi_stm32f4.c hal_uart_stm32f4.c hw.c
  group osal
    ../../../../././osal/aos/: aos_common.c aos_kv.c aos_rhino.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group yloop
    ../../../.././network/yloop/: device.c local_event.c select.c yloop.c
  group cli
    ../../../.././tools/cli/: cli.c dumpsys.c
  group sal
    ../../../.././middleware/linkkit/sdk-c/src/services/mdal/sal/./src/: ip4_addr.c sal_arch_aos.c sal_err.c sal_sockets.c
  group armv7m
    ../../../../././platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.S
    ../../../../././platform/arch/arm/armv7m/panic/: panic_armcc.S panic_c.c
  group newlib_stub
    ../../../.././utility/libc/compilers/armlibc/: armcc_libc.c hal_stub.c
  group rhino
    ../../../.././kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_spin_lock.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group hal
    ../../../.././kernel/hal/: hal.c
  group halwifi
    ../../../.././network/halwifi/: wifi.c
  group vfs
    ../../../../././kernel/fs/vfs/: vfs.c vfs_file.c vfs_inode.c vfs_register.c
  group kv
    ../../../../././kernel/fs/kv/: kv.c kv_adapt.c kv_cli.c
  group digest_algorithm
    ../../../.././utility/digest_algorithm/: CheckSumUtils.c crc.c crc16.c digest_algorithm.c md5.c
  group common
    ../../../../././middleware/common/: main.c version.c
  group log
    ../../../.././utility/log/: log.c
  group device_sal_mk3060
    ../../../.././network/sal/wifi/mk3060/: mk3060.c wifi_atcmd.c
  group vfs_device
    ../../../../././kernel/fs/vfs/device/: vfs_adc.c vfs_gpio.c vfs_i2c.c vfs_pwm.c vfs_rtc.c vfs_spi.c vfs_uart.c vfs_wdg.c
  group atparser
    ../../../../././network/sal/atparser/: atparser.c
