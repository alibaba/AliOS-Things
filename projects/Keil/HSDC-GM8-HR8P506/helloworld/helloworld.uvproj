# Keil uVision project helloworld.uvproj, settings and files
target HR8P506 (ARM-ADS)
  device: HR8P506FHLQ HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: helloworld +hex
  c flags: Optim=1 OneElfS=1
  c define: __PRINTF_USE_UART0__,AOS_KV
  c misc: --bitband --C99 -DCONFIG_NO_TCPIP
  c include: ..\..\..\..\kernel\rhino\core\include;..\..\..\..\platform\arch\arm\armv6m\armcc\m0plus;..\..\..\..\include;..\..\..\..\include\hal;..\..\..\..\kernel\vcall\aos;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\include\aos;..\..\..\..\test\yunit\include;..\..\..\..\platform\mcu\hr8p506\cmsis;..\..\..\..\platform\mcu\hr8p506\HRSDK_GDB_HR8P506\helloworld;..\..\..\..\platform\mcu\hr8p506\library\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group platform\mcu\hr8p506\Source
    ../../../../platform/mcu/hr8p506/library/Source/: hr8p506_iap_table.c lib_adc.c lib_euart.c lib_gpio.c lib_iic.c lib_lcd.c lib_led.c lib_printf.c lib_rtc.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group platform\mcu\hr8p506\HRSDK_GDB_HR8P506
    ../../../../platform/mcu/hr8p506/HRSDK_GDB_HR8P506/: startup_HR8P506.s
    ../../../../platform/mcu/hr8p506/HRSDK_GDB_HR8P506/helloworld/: irqhandler.c system_HR8P506.c sdk_init.c
  group kernel\rhino\core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_obj_set.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group platform\mcu\hr8p506\aos
    ../../../../platform/mcu/hr8p506/aos/: soc_impl.c
  group platform\arch\arm\armv6m\armcc\m0plus
    ../../../../platform/arch/arm/armv6m/armcc/m0plus/: port_c.c port_s.s
  group example\esapp\helloworld
    ../../../../platform/mcu/hr8p506/HRSDK_GDB_HR8P506/helloworld/: helloworld.c hook_impl.c
