# Keil uVision project STM32L433RCTxP.uvprojx, settings and files
target STM32L433RCTxP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L433RCTxP
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L433xx,CONFIG_AOS_CLI,VCALL_RHINO
  c misc: --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32L433RCTxP\" -DSYSINFO_DEVICE_NAME=\"STM32L433RCTxP\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.3.0\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\..\..\..\include;..\..\..\..\kernel\rhino\core\include;..\..\..\..\platform\arch\arm\armv7m\armcc\m4;..\..\..\..\platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\mcu\stm32l4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\mcu\stm32l4xx\Drivers\CMSIS\Include;..\..\..\..\platform\mcu\stm32l4xx\src\STM32L433RC-Nucleo\cli_pro;..\..\..\..\include\hal;..\..\..\..\kernel\vcall\aos;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\tools\cli;..\..\..\..\platform\mcu\stm32l4xx\src\STM32L433RC-Nucleo\hal;..\..\..\..\kernel\vfs\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: ..\..\..\..\platform\mcu\stm32l4xx\src\STM32L433RC-Nucleo\STM32L433.sct
  link misc: --diag_suppress=L6329
  group platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Src
    ../../../../platform/mcu/stm32l4xx/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_tim.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c_ex.c
  group platform\mcu\stm32l4xx\src\STM32L433RC-Nucleo
    ../../../../platform/mcu/stm32l4xx/src/STM32L433RC-Nucleo/cli_pro/: soc_init.c stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
    ../../../../platform/mcu/stm32l4xx/src/STM32L433RC-Nucleo/: startup_stm32l433xx_keil.s
  group kernel\rhino\core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group utility\libc\compilers\armlibc
    ../../../../utility/libc/compilers/armlibc/: armcc_libc.c
  group platform\mcu\stm32l4xx\aos
    ../../../../platform/mcu/stm32l4xx/aos/: soc_impl.c trace_impl.c
  group platform\arch\arm\armv7m\armcc\m4
    ../../../../platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.S
  group example
    ../../../../example/rhinorun/: rhinorun.c
  group tools\cli
    ../../../../tools/cli/: dumpsys.c cli.c
  group utility\log
    ../../../../utility/log/: log.c
  group platform\mcu\stm32l4xx\src\STM32L433RC-Nucleo\hal
    ../../../../platform/mcu/stm32l4xx/src/STM32L433RC-Nucleo/hal/: hal_uart_stm32l4.c
  group kernel\vfs
    ../../../../kernel/vfs/: vfs.c vfs_file.c vfs_inode.c
  group kernel\vcall
    ../../../../kernel/vcall/aos/: aos_rhino.c
software components: CMSIS:CORE 5.0.2
