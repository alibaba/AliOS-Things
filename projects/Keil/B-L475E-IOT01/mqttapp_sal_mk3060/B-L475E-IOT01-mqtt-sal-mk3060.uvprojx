# Keil uVision project B-L475E-IOT01-mqtt-sal-mk3060.uvprojx, settings and files
target B-L475E-IOT01 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: B-L475E-IOT01
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx,VCALL_RHINO,AOS_KV,AOS_VFS,AOS_LOOP,AOS_FRAMEWORK_COMMON,CONFIG_AOS_CLI,AOS_FOTA,AOS_ATCMD,DEV_SAL_MK3060
  c misc: -DSYSINFO_OS_VERSION=\"APP-1.0.0-20171128.1211\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32L475VGT6\" -DSYSINFO_DEVICE_NAME=\"STM32L475VGT6\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.2.2\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0 -DWITH_SAL=1
  c include: ../../../../include;../../../../board/b_l475e;../../../../kernel/rhino/core/include;../../../../platform/arch/arm/armv7m/armcc/m4;../../../../platform/mcu/stm32l475/Drivers/STM32L4xx_HAL_Driver/Inc;../../../../platform/mcu/stm32l475/Drivers/BSP/B-L475E-IOT01;../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/include;../../../../platform/mcu/stm32l475/Drivers/BSP/Components/es_wifi;../../../../platform/mcu/stm32l475/Drivers/BSP/Components/hts221;../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lis3mdl;../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lps22hb;../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lsm6dsl;../../../../platform/mcu/stm32l475/Drivers/BSP/Components/vl53l0x;../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/runapp;../../../../platform/mcu/stm32l475/Drivers/CMSIS/Include;../../../../platform/mcu/stm32l475/src/common/csp/wifi/inc;../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/hal;../../../../kernel/modules/fs/kv/include;../../../../kernel/vcall/aos;../../../../kernel/vfs/include;../../../../kernel/yloop;../../../../utility/libc/compilers/armlibc;../../../../platform/mcu/stm32l4xx/hal;../../../../utility/digest_algorithm;../../../../framework/connectivity/mqtt;../../../../framework/connectivity/mqtt/MQTTPacket;../../../../utility/iotx-utils/iotx-system;../../../../utility/iotx-utils/digest;../../../../utility/iotx-utils/guider;../../../../utility/iotx-utils/LITE-log;../../../../utility/iotx-utils/LITE-utils;../../../../utility/iotx-utils/misc;../../../../utility/iotx-utils/sdk-impl;../../../../utility/iotx-utils/sdk-impl/imports;../../../../utility/iotx-utils/sdk-impl/exports;../../../../security/mbedtls/include;../../../../framework/netmgr/include;..\..\..\..\security\alicrypto\libalicrypto\inc;../../../../framework/fota;../../../../framework/fota/platform;../../../../framework/fota/download;../../../../framework/fota/download/http/socket;../../../../utility/cjson/include;..\..\..\..\utility\iotx-utils\iotx-system;..\..\..\..\device\sal\include;..\..\..\..\device\sal\wifi\mk3060;..\..\..\..\framework\atparser
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: ..\..\..\..\platform\mcu\stm32l475\B-L475E-IOT01.sct
  group platform/mcu/stm32l475/Drivers/BSP/B-L475E-IOT01
    ../../../../platform/mcu/stm32l475/Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_qspi.c stm32l475e_iot01_tsensor.c
  group platform/mcu/stm32l475/Drivers/BSP/Components/es_wifi
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/es_wifi/: es_wifi.c
  group platform/mcu/stm32l475/Drivers/BSP/Components/hts221
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/hts221/: hts221.c
  group platform/mcu/stm32l475/Drivers/BSP/Components/lis3mdl
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group platform/mcu/stm32l475/Drivers/BSP/Components/lps22hb
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lps22hb/: lps22hb.c
  group platform/mcu/stm32l475/Drivers/BSP/Components/lsm6dsl
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group platform/mcu/stm32l475/Drivers/BSP/Components/vl53l0x
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group platform/mcu/stm32l475/src/B-L475E-IOT01/runapp
    ../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/runapp/: system_stm32l4xx.c aos.c soc_init.c stm32l4xx_hal_msp.c stm32l4xx_it.c startup_stm32l475xx_armcc.s
  group platform/mcu/stm32l475/Drivers/STM32L4xx_HAL_Driver/Src
    ../../../../platform/mcu/stm32l475/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group platform/arch/arm/armv7m/armcc/m4
    ../../../../platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.S
  group platform/mcu/stm32l475/aos
    ../../../../platform/mcu/stm32l475/aos/: soc_impl.c trace_impl.c
  group platform/mcu/stm32l475/src/B-L475E-IOT01/hal
    ../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/hal/: flash_l4.c flash_port.c hw.c ota_port.c wifi_port.c
  group platform/mcu/stm32l475/src/common/csp/wifi/src
    ../../../../platform/mcu/stm32l475/src/common/csp/wifi/src/: es_wifi_io.c wifi.c
  group platform/mcu/stm32l475/src/B-L475E-IOT01/sensor
    ../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/sensor/: sensors_data.c vl53l0x_platform.c vl53l0x_proximity.c
  group board/b_l475e
    ../../../../board/b_l475e/: board.c osa_flash.c
  group kernel/rhino/core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
    ../../../../kernel/rhino/common/: k_fifo.c k_trace.c
  group kernel/hal
    ../../../../kernel/hal/: ota.c wifi.c
  group kernel/init
    ../../../../kernel/init/: aos_init.c
  group kernel/modules/fs/kv
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group kernel/vcall/aos
    ../../../../kernel/vcall/aos/: aos_rhino.c
  group kernel/vfs
    ../../../../kernel/vfs/: device.c vfs.c vfs_inode.c vfs_register.c select.c vfs_file.c
  group kernel/yloop
    ../../../../kernel/yloop/: local_event.c yloop.c
  group framework/common
    ../../../../framework/common/: main.c version.c
  group framework/connectivity/mqtt
    ../../../../framework/connectivity/mqtt/: mqtt_client.c
    ../../../../framework/connectivity/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group framework/fota
    ../../../../framework/fota/: ota_service.c ota_update_manifest.c ota_util.c ota_version.c
    ../../../../framework/fota/platform/: ota_platform_os.c
    ../../../../framework/fota/platform/mqtt/: ota_transport.c
    ../../../../framework/fota/download/: download_common.c
    ../../../../framework/fota/download/http/: ota_download.c
    ../../../../framework/fota/download/http/socket/stand/: ota_socket.c
  group framework/netmgr
    ../../../../framework/netmgr/: netmgr.c
  group tools/cli
    ../../../../tools/cli/: cli.c dumpsys.c
  group utility/libc
    ../../../../utility/libc/compilers/armlibc/: armcc_libc.c
  group utility/digest_algorithm
    ../../../../utility/digest_algorithm/: CheckSumUtils.c md5.c
  group utility/log
    ../../../../utility/log/: log.c
  group utility/iotx-utils/iotx-system
    ../../../../utility/iotx-utils/iotx-system/: ca.c device.c
  group utility/iotx-utils/digest
    ../../../../utility/iotx-utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
  group utility/cjson
    ../../../../utility/cjson/: cJSON.c
  group utility/iotx-utils/guider
    ../../../../utility/iotx-utils/guider/: guider.c
  group utility/iotx-utils/hal/rhino
    ../../../../utility/iotx-utils/hal/rhino/: HAL_OS_rhino.c HAL_TCP_rhino.c
  group utility/iotx-utils/mbedtls-hal
    ../../../../utility/iotx-utils/mbedtls-hal/: HAL_TLS_mbedtls.c
  group utility/iotx-utils/LITE-log
    ../../../../utility/iotx-utils/LITE-log/: lite-log.c
  group utility/iotx-utils/LITE-utils
    ../../../../utility/iotx-utils/LITE-utils/: json_parser.c json_token.c mem_stats.c string_utils.c
  group utility/iotx-utils/misc
    ../../../../utility/iotx-utils/misc/: utils_epoch_time.c utils_httpc.c utils_list.c utils_net.c utils_timer.c
  group utility/iotx-utils/sdk-impl
    ../../../../utility/iotx-utils/sdk-impl/: sdk-impl.c
  group example/mqttapp
    ../../../../example/mqttapp/: mqtt-example.c
  group security/mbedtls
    ../../../../security/mbedtls/src/: mbedtls_net.c mbedtls_ssl.c mbedtls_alt.c
  group security/mbedtls/lib
    ../../../../security/mbedtls/lib/Cortex-M4/KEIL/: libmbedtls.lib
  group security/alicrypto/lib
    ../../../../security/alicrypto/lib/Cortex-M4/KEIL/: libalicrypto.lib libmbedcrypto.lib
  group device
    ../../../../device/sal/: ip4_addr.c sal.c sal_arch.c sal_device.c sal_err.c sal_sockets.c
    ../../../../device/sal/wifi/mk3060/: mk3060.c wifi_atcmd.c
  group framework/atparser
    ../../../../framework/atparser/: atparser.c
