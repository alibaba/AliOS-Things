# Keil uVision project mqttapp@numaker-iot-m487.uvprojx, settings and files
target mqttapp@numaker-iot-m487 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.1
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: mqttapp@numaker-iot-m487
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: ..\..\..\..\platform\mcu\m487jidae\M487.sct
  group mqttapp
    ../../../.././app/example/mqttapp/: app_entry.c mqtt_example.c
  group numaker-iot-m487
    ../../../.././board/numaker-iot-m487/aos/: board.c board_cli.c soc_init.c
    ../../../.././board/numaker-iot-m487/: startup_M480.c
  group m487jidae
    ../../../../././platform/mcu/m487jidae/Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../././platform/mcu/m487jidae/Library/StdDriver/src/: clk.c crypto.c dac.c eadc.c epwm.c fmc.c gpio.c i2c.c i2s.c pdma.c qspi.c retarget.c rtc.c sdh.c spi.c spim.c sys.c timer.c timer_pwm.c uart.c wdt.c
    ../../../../././platform/mcu/m487jidae/aos/: aos.c soc_impl.c trace_impl.c
    ../../../../././platform/mcu/m487jidae/hal/common/: PeripheralPins.c pinmap.c pinmap_common.c
    ../../../../././platform/mcu/m487jidae/hal/: hal_adc.c hal_dac.c hal_dma.c hal_flash.c hal_gpio.c hal_i2c.c hal_interrupt.c hal_pwm.c hal_qspi.c hal_rng.c hal_rtc.c hal_sd.c hal_spi.c hal_timer.c hal_uart.c hal_wdg.c hw.c ota_port.c ota_spimflash.c
    ../../../../././platform/mcu/m487jidae/hal/misc/: nu_modutil.c
  group osal
    ../../../../././osal/aos/: aos_rhino.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group netmgr
    ../../../../././network/netmgr/interfaces/: netmgr_wifi.c
    ../../../../././network/netmgr/: netmgr.c
  group common
    ../../../../././middleware/common/: main.c version.c
  group cjson
    ../../../../././utility/cjson/: cJSON.c cJSON_Utils.c
  group cli
    ../../../../././tools/cli/: cli.c dumpsys.c
  group sal
    ../../../.././network/sal/: ip4_addr.c sal.c sal_arch.c sal_device.c sal_err.c sal_sockets.c
  group device_sal_esp8266_aos
    ../../../.././network/sal/wifi/esp8266_aos/: esp8266.c esp8266_at.c ringbuffer.c wifi_port.c
  group armv7m
    ../../../../././platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.S
    ../../../../././platform/arch/arm/armv7m/panic/: panic_armcc.S panic_c.c
  group newlib_stub
    ../../../.././utility/libc/compilers/armlibc/: armcc_libc.c hal_stub.c
  group rhino
    ../../../.././kernel/rhino/common/: k_fifo.c k_trace.c
    ../../../.././kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
    ../../../.././kernel/rhino/debug/: k_backtrace.c k_infoget.c k_overview.c k_panic.c
    ../../../.././kernel/rhino/uspace/: u_task.c
  group hal
    ../../../.././kernel/hal/: ota.c wifi.c
  group vfs
    ../../../.././kernel/rhino/vfs/: vfs.c vfs_file.c vfs_inode.c vfs_register.c
  group digest_algorithm
    ../../../.././utility/digest_algorithm/: CheckSumUtils.c crc.c crc16.c digest_algorithm.c md5.c
  group cloud
    ../../../../././middleware/alink/cloud/: cloud.c
  group kv
    ../../../.././kernel/rhino/fs/kv/: kv_osal.c kvmgr.c
  group yloop
    ../../../.././kernel/yloop/: device.c local_event.c select.c yloop.c
  group vfs_device
    ../../../../././kernel/rhino/vfs/device/: vfs_adc.c vfs_gpio.c vfs_i2c.c vfs_pwm.c vfs_rtc.c vfs_spi.c vfs_uart.c vfs_wdg.c
  group log
    ../../../.././utility/log/: log.c
  group iotx-hal
    ../../../../././middleware/linkkit/hal/: HAL_AWSS_rhino.c HAL_Crypt_rhino.c HAL_DTLS_mbedtls.c HAL_OS_rhino.c HAL_PRODUCT_rhino.c HAL_TCP_rhino.c HAL_TLS_mbedtls.c HAL_UDP_rhino.c
  group libiot_mqtt
    ../../../../././middleware/linkkit/sdk-c/src/protocol/mqtt/./MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
    ../../../../././middleware/linkkit/sdk-c/src/protocol/mqtt/./client/: mqtt_client.c mqtt_instance.c
  group activation
    ../../../.././tools/activation/./Cortex-M4/KEIL/: activation.a
  group chip_code
    ../../../.././utility/chip_code/: chip_code.c
  group mbedtls
    ../../../../././security/mbedtls/src/: aes.c aesni.c arc4.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c mbedtls_alt.c mbedtls_net.c mbedtls_ssl.c md.c md2.c md4.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../././security/mbedtls/lib/Cortex-M4/KEIL/: libmbedtls.lib
  group libiot_utils
    ../../../../././middleware/linkkit/sdk-c/src/infra/utils/./digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c utils_sha256.c
    ../../../../././middleware/linkkit/sdk-c/src/infra/utils/./misc/: json_parser.c json_token.c linked_list.c lite-cjson.c mem_stats.c string_utils.c utils_epoch_time.c utils_event.c utils_httpc.c utils_list.c utils_net.c utils_timer.c
  group libiot_log
    ../../../../././middleware/linkkit/sdk-c/src/infra/log/./: iotx_log.c
  group libiot_system
    ../../../../././middleware/linkkit/sdk-c/src/infra/system/./: ca.c device.c guider.c report.c
  group libiot_sdk_impl
    ../../../../././middleware/linkkit/sdk-c/src/sdk-impl/./: impl_dynreg.c impl_linkkit.c impl_logpost.c sdk-impl.c
  group alicrypto
    ../../../.././security/alicrypto/./libalicrypto/: ali_crypto.c
    ../../../.././security/alicrypto/./libalicrypto/mbed/asym/: rsa.c
    ../../../.././security/alicrypto/./libalicrypto/mbed/cipher/: aes.c
    ../../../.././security/alicrypto/./libalicrypto/mbed/hash/: hash.c
    ../../../.././security/alicrypto/./libalicrypto/mbed/mac/: hmac.c
    ../../../.././security/alicrypto/./libalicrypto/sw/: ali_crypto_rand.c
    ../../../.././security/alicrypto/./mbedtls/library/: aes_nuvoton.c asn1parse.c bignum.c hash_wrap.c hmac.c mbedtls_alt.c md5.c oid.c rsa.c sha1.c sha256.c threading.c
