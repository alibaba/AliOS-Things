# Keil uVision project cm4.uvprojx, settings and files
target certification (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CY8C6347BZI-BLD53_Pack:CortexM4 Cypress
  pack: Cypress.Pack.5.2.4
  cpu: IRAM(0x8000000,0x48000) IROM(0x10000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: cm4 +hex
  AfterMake: $KARM\PACK\Cypress\Pack\5.2.4\Device\CY8C6347BZI-BLD53_Pack\Other\postbuildCortexM4.bat "#L" -p "$P" "cmsis" "$KARM\PACK\Cypress\Pack\5.2.4\Device\CY8C6347BZI-BLD53_Pack\Other\win\elf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_NO_TCPIP
  c include: ..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\drivers\peripheral;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\cmsis\include;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\devices\psoc6\ip;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\devices\psoc6\psoc63\include;..\..\..\..\platform\mcu\cy8c6347\drivers\PSoC6\pdl\middleware;..\..\..\..\platform\mcu\cy8c6347\drivers;..\..\..\..\board\cy8ckit-062;..\..\..\..\test\testcase\include;..\..\..\..\test\yunit\include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x8000000 size 0x48000
  scatter file: ..\..\..\..\platform\mcu\cy8c6347\drivers\linker_file\cy8c6xx7_cm4_dual.scat
  group board_b_l475e
    ../../../../board/cy8ckit-062/: board.c
  group cli
    ../../../.././tools/cli/: cli.c dumpsys.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group newlib_stub
    ../../../.././utility/libc/compilers/armlibc/: armcc_libc.c
  group log
    ../../../.././utility/log/: log.c
  group kv
    ../../../.././kernel/modules/fs/kv/: kvmgr.c
  group mqttapp
    ../../../../test/testcase/certificate_test/: aos_test.c
    ../../../../test/testcase/certificate_test/cutest/: cut.c
    ../../../../test/testcase/: yts_main.c
    ../../../../test/yunit/: yunit.c
    ./auto/: component_init.c testcase_register.c
  group armv7m
    ../../../../././platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.S
  group stm32l475
    ../../../../platform/mcu/cy8c6347/aos/: soc_impl.c trace_impl.c
    ../../../../platform/mcu/cy8c6347/drivers/: cy_ipc_config.c system_psoc63_cm4.c
    ../../../../platform/mcu/cy8c6347/drivers/startup/: startup_psoc63_cm4.s
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/: cyfitter_sysint_cfg.c cymetadata.c UART1.c UART5.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/flash/: cy_flash.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/gpio/: cy_gpio.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/ipc/: cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/scb/: cy_scb_common.c cy_scb_ezi2c.c cy_scb_i2c.c cy_scb_spi.c cy_scb_uart.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/sysclk/: cy_sysclk.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/sysint/: cy_sysint.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syslib/: cy_syslib.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syslib/mdk/: cy_syslib_mdk.s
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/syspm/: cy_syspm.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/systick/: cy_systick.c
    ../../../../platform/mcu/cy8c6347/drivers/PSoC6/pdl/drivers/peripheral/wdt/: cy_wdt.c
    ../../../../platform/mcu/cy8c6347/hal/: flash_port.c hw.c uart_port.c
    ../../../../platform/mcu/cy8c6347/runapp/: aos.c
  group rhino
    ../../../.././kernel/rhino/common/: k_fifo.c k_trace.c
    ../../../.././kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group vcall
    ../../../.././kernel/vcall/aos/: aos_rhino.c
  group vfs
    ../../../.././kernel/vfs/: device.c select.c vfs.c vfs_file.c vfs_inode.c vfs_register.c
  group yloop
    ../../../.././kernel/yloop/: local_event.c yloop.c
