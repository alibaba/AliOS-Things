# Keil uVision project template_numicro.uvprojx, settings and files
target helloworld@numaker-pfm-m487 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.2.1
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: helloworld@numaker-pfm-m487
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: ..\..\..\..\platform\mcu\numicro_m48x\M487.sct
