# IAR project template_stm32f429zi-nucleo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkIcfFile: ../../../../platform/board/stm32f429zi-nucleo/STM32F429.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
