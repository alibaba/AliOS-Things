# Keil uVision project template_stm32l073rz-nucleo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template_stm32l073rz-nucleo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
