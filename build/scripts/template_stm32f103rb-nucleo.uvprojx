# Keil uVision project template_stm32f103rb-nucleo.uvprojx, settings and files
target B-L475E-IOT01 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  output: B-L475E-IOT01
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ../../../../platform/board/stm32f103rb-nucleo/stm32f103rb-nucleo.sct
