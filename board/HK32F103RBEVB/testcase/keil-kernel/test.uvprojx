# Keil uVision project test.uvprojx, settings and files
target test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: drivers +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Inc;..\..\..\..\platform\mcu\hk32f103\HK32F1xx_HAL_Driver\Inc;..\..\..\..\platform\mcu\hk32f103\CMSIS\Include;..\..\..\..\kernel\hal\include;..\..\..\..\osal\include;..\..\..\..\utility\libc\compilers\armlibc\sys;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\kernel\rhino\core\include;..\..\aos;..\..\..\..\platform\arch\arm\armv7m\armcc\m3;..\..\..\..\tools\cli\include;..\..\..\..\middleware\alink\cloud\include;..\..\..\..\kernel\rhino\fs\kv\include;..\..\..\..\utility\log\include;..\..\..\..\kernel\rhino\vfs\include;..\..\..\..\middleware\common\include;..\..\..\..\kernel\yloop\include;..\..\..\..\kernel\init\include;..\..\..\..\kernel\rhino;..\..\hal;..\..\..\..\platform\mcu\windows\include;..\..\..\..\utility\libc\compilers\armlibc\RVMDK;..\..\..\..\network\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group HKF103RB-EVB
    ../../: startup_hk32f103xb_keil.s
    ../../aos/: soc_init.c
    ../../Src/: main.c hk32f1xx_it.c system_hk32f1xx.c hk32f1xx_hal_msp.c
  group hk32f103rb
    ../../../../platform/mcu/hk32f103/aos/: soc_impl.c
  group drivers
    ../../../../platform/mcu/hk32f103/HK32F1xx_HAL_Driver/Src/: driver.lib
  group armv7m
    ../../../../platform/arch/arm/armv7m/armcc/m3/: port_c.c port_s.s
  group rhino
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group stub
    ../../../../utility/libc/compilers/armlibc/: armcc_libc.c hal_stub.c
  group certificate_test
    ../certificate_test/: rhino_test.c
    ../certificate_test/cutest/: cut.c
